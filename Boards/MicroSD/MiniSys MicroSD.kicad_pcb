# Repository ab0tj/MiniSys (continued)

## KiCad design Boards/8MB SRAM/8MB SRAM.kicad_pcb

Parts:
C1, C2: 33uF; CP_EIA-3528-15_AVX-H_Pad1.50x2.35mm_HandSolder
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29: .1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: CheapBusTX24-RA; JAE_TX24-120R-LT-H1E; Mouser Part Number 656-TX24120RLTH1E
JP1: IN; PinHeader_1x02_P2.54mm_Vertical
JP2: A23; PinHeader_1x02_P2.54mm_Vertical
JP3: OUT; PinHeader_1x02_P2.54mm_Vertical
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: IS61C5128AL-10KLI; SOJ-36_10.16x23.49mm_P1.27mm
U17, U18, U23, U24: 74HCT244; SOIC-20W_7.5x12.8mm_P1.27mm
U19, U20, U25, U26: 74HCT257; SOIC-16_3.9x9.9mm_P1.27mm
U21: 74HCT138; SOIC-16_3.9x9.9mm_P1.27mm
U22: GAL16V8; PLCC-20_THT-Socket
U27: 74HCT125; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, J1.58 (5V), J1.59 (5V), J1.60 (5V), J1.61 (5V), J1.62 (5V), U1.9 (VDD), U1.27 (VDD), U2.9 (VDD), U2.27 (VDD), U3.9 (VDD), U3.27 (VDD), U4.9 (VDD), U4.27 (VDD), U5.9 (VDD), U5.27 (VDD), U6.9 (VDD), U6.27 (VDD), U7.9 (VDD), U7.27 (VDD), U8.9 (VDD), U8.27 (VDD), U9.9 (VDD), U9.27 (VDD), U10.9 (VDD), U10.27 (VDD), U11.9 (VDD), U11.27 (VDD), U12.9 (VDD), U12.27 (VDD), U13.9 (VDD), U13.27 (VDD), U14.9 (VDD), U14.27 (VDD), U15.9 (VDD), U15.27 (VDD), U16.9 (VDD), U16.27 (VDD), U17.20 (VCC), U18.20 (VCC), U19.16 (VCC), U20.16 (VCC), U21.6 (G1), U21.16 (VCC), U22.20 (VCC), U23.20 (VCC), U24.20 (VCC), U25.16 (VCC), U26.16 (VCC), U27.14 (VCC)
/A0: J1.29 (A0), U22.2 (I2)
/A1: J1.28 (A1), U17.2 (1A0)
/A2: J1.27 (A2), U17.4 (1A1)
/A3: J1.26 (A3), U17.6 (1A2)
/A4: J1.25 (A4), U17.8 (1A3)
/A5: J1.24 (A5), U17.17 (2A0)
/A6: J1.23 (A6), U17.15 (2A1)
/A7: J1.22 (A7), U17.13 (2A2)
/A8: J1.21 (A8), U17.11 (2A3)
/A9: J1.20 (A9), U23.2 (1A0)
/A10: J1.19 (A10), U23.4 (1A1)
/A11: J1.18 (A11), U23.6 (1A2)
/A12: J1.17 (A12), U23.8 (1A3)
/A13: J1.16 (A13), U23.17 (2A0)
/A14: J1.15 (A14), U23.15 (2A1)
/A15: J1.14 (A15), U23.13 (2A2)
/A16: J1.13 (A16), U23.11 (2A3)
/A17: J1.12 (A17), U27.2
/A18: J1.11 (A18), U27.5
/A19: J1.10 (A19), U27.9
/A20: J1.9 (A20), U21.1 (A0)
/A21: J1.8 (A21), U21.2 (A1)
/A22: J1.7 (A22), U21.3 (A2)
/A23: J1.6 (A23), U22.1 (I1/CLK)
/D0: J1.81 (D0), U18.2 (1A0), U19.4 (Za), U20.2 (I0a)
/D1: J1.80 (D1), U18.4 (1A1), U19.7 (Zb), U20.5 (I0b)
/D2: J1.79 (D2), U18.6 (1A2), U19.12 (Zc), U20.14 (I0c)
/D3: J1.78 (D3), U18.8 (1A3), U19.9 (Zd), U20.11 (I0d)
/D4: J1.77 (D4), U18.17 (2A0), U25.4 (Za), U26.2 (I0a)
/D5: J1.76 (D5), U18.15 (2A1), U25.7 (Zb), U26.5 (I0b)
/D6: J1.75 (D6), U18.13 (2A2), U25.12 (Zc), U26.14 (I0c)
/D7: J1.74 (D7), U18.11 (2A3), U25.9 (Zd), U26.11 (I0d)
/D8: J1.73 (D8), U20.3 (I1a), U24.18 (1Y0)
/D9: J1.72 (D9), U20.6 (I1b), U24.16 (1Y1)
/D10: J1.71 (D10), U20.13 (I1c), U24.14 (1Y2)
/D11: J1.70 (D11), U20.10 (I1d), U24.12 (1Y3)
/D12: J1.69 (D12), U24.3 (2Y0), U26.3 (I1a)
/D13: J1.68 (D13), U24.5 (2Y1), U26.6 (I1b)
/D14: J1.67 (D14), U24.7 (2Y2), U26.13 (I1c)
/D15: J1.66 (D15), U24.9 (2Y3), U26.10 (I1d)
/MA0: U1.1 (A0), U2.1 (A0), U3.1 (A0), U4.1 (A0), U5.1 (A0), U6.1 (A0), U7.1 (A0), U8.1 (A0), U9.1 (A0), U10.1 (A0), U11.1 (A0), U12.1 (A0), U13.1 (A0), U14.1 (A0), U15.1 (A0), U16.1 (A0), U17.18 (1Y0)
/MA1: U1.2 (A1), U2.2 (A1), U3.2 (A1), U4.2 (A1), U5.2 (A1), U6.2 (A1), U7.2 (A1), U8.2 (A1), U9.2 (A1), U10.2 (A1), U11.2 (A1), U12.2 (A1), U13.2 (A1), U14.2 (A1), U15.2 (A1), U16.2 (A1), U17.16 (1Y1)
/MA2: U1.3 (A2), U2.3 (A2), U3.3 (A2), U4.3 (A2), U5.3 (A2), U6.3 (A2), U7.3 (A2), U8.3 (A2), U9.3 (A2), U10.3 (A2), U11.3 (A2), U12.3 (A2), U13.3 (A2), U14.3 (A2), U15.3 (A2), U16.3 (A2), U17.14 (1Y2)
/MA3: U1.4 (A3), U2.4 (A3), U3.4 (A3), U4.4 (A3), U5.4 (A3), U6.4 (A3), U7.4 (A3), U8.4 (A3), U9.4 (A3), U10.4 (A3), U11.4 (A3), U12.4 (A3), U13.4 (A3), U14.4 (A3), U15.4 (A3), U16.4 (A3), U17.12 (1Y3)
/MA4: U1.5 (A4), U2.5 (A4), U3.5 (A4), U4.5 (A4), U5.5 (A4), U6.5 (A4), U7.5 (A4), U8.5 (A4), U9.5 (A4), U10.5 (A4), U11.5 (A4), U12.5 (A4), U13.5 (A4), U14.5 (A4), U15.5 (A4), U16.5 (A4), U17.3 (2Y0)
/MA5: U1.14 (A5), U2.14 (A5), U3.14 (A5), U4.14 (A5), U5.14 (A5), U6.14 (A5), U7.14 (A5), U8.14 (A5), U9.14 (A5), U10.14 (A5), U11.14 (A5), U12.14 (A5), U13.14 (A5), U14.14 (A5), U15.14 (A5), U16.14 (A5), U17.5 (2Y1)
/MA6: U1.15 (A6), U2.15 (A6), U3.15 (A6), U4.15 (A6), U5.15 (A6), U6.15 (A6), U7.15 (A6), U8.15 (A6), U9.15 (A6), U10.15 (A6), U11.15 (A6), U12.15 (A6), U13.15 (A6), U14.15 (A6), U15.15 (A6), U16.15 (A6), U17.7 (2Y2)
/MA7: U1.16 (A7), U2.16 (A7), U3.16 (A7), U4.16 (A7), U5.16 (A7), U6.16 (A7), U7.16 (A7), U8.16 (A7), U9.16 (A7), U10.16 (A7), U11.16 (A7), U12.16 (A7), U13.16 (A7), U14.16 (A7), U15.16 (A7), U16.16 (A7), U17.9 (2Y3)
/MA8: U1.17 (A8), U2.17 (A8), U3.17 (A8), U4.17 (A8), U5.17 (A8), U6.17 (A8), U7.17 (A8), U8.17 (A8), U9.17 (A8), U10.17 (A8), U11.17 (A8), U12.17 (A8), U13.17 (A8), U14.17 (A8), U15.17 (A8), U16.17 (A8), U23.18 (1Y0)
/MA9: U1.18 (A9), U2.18 (A9), U3.18 (A9), U4.18 (A9), U5.18 (A9), U6.18 (A9), U7.18 (A9), U8.18 (A9), U9.18 (A9), U10.18 (A9), U11.18 (A9), U12.18 (A9), U13.18 (A9), U14.18 (A9), U15.18 (A9), U16.18 (A9), U23.16 (1Y1)
/MA10: U1.20 (A10), U2.20 (A10), U3.20 (A10), U4.20 (A10), U5.20 (A10), U6.20 (A10), U7.20 (A10), U8.20 (A10), U9.20 (A10), U10.20 (A10), U11.20 (A10), U12.20 (A10), U13.20 (A10), U14.20 (A10), U15.20 (A10), U16.20 (A10), U23.14 (1Y2)
/MA11: U1.21 (A11), U2.21 (A11), U3.21 (A11), U4.21 (A11), U5.21 (A11), U6.21 (A11), U7.21 (A11), U8.21 (A11), U9.21 (A11), U10.21 (A11), U11.21 (A11), U12.21 (A11), U13.21 (A11), U14.21 (A11), U15.21 (A11), U16.21 (A11), U23.12 (1Y3)
/MA12: U1.22 (A12), U2.22 (A12), U3.22 (A12), U4.22 (A12), U5.22 (A12), U6.22 (A12), U7.22 (A12), U8.22 (A12), U9.22 (A12), U10.22 (A12), U11.22 (A12), U12.22 (A12), U13.22 (A12), U14.22 (A12), U15.22 (A12), U16.22 (A12), U23.3 (2Y0)
/MA13: U1.23 (A13), U2.23 (A13), U3.23 (A13), U4.23 (A13), U5.23 (A13), U6.23 (A13), U7.23 (A13), U8.23 (A13), U9.23 (A13), U10.23 (A13), U11.23 (A13), U12.23 (A13), U13.23 (A13), U14.23 (A13), U15.23 (A13), U16.23 (A13), U23.5 (2Y1)
/MA14: U1.24 (A14), U2.24 (A14), U3.24 (A14), U4.24 (A14), U5.24 (A14), U6.24 (A14), U7.24 (A14), U8.24 (A14), U9.24 (A14), U10.24 (A14), U11.24 (A14), U12.24 (A14), U13.24 (A14), U14.24 (A14), U15.24 (A14), U16.24 (A14), U23.7 (2Y2)
/MA15: U1.32 (A15), U2.32 (A15), U3.32 (A15), U4.32 (A15), U5.32 (A15), U6.32 (A15), U7.32 (A15), U8.32 (A15), U9.32 (A15), U10.32 (A15), U11.32 (A15), U12.32 (A15), U13.32 (A15), U14.32 (A15), U15.32 (A15), U16.32 (A15), U23.9 (2Y3)
/MA16: U1.33 (A16), U2.33 (A16), U3.33 (A16), U4.33 (A16), U5.33 (A16), U6.33 (A16), U7.33 (A16), U8.33 (A16), U9.33 (A16), U10.33 (A16), U11.33 (A16), U12.33 (A16), U13.33 (A16), U14.33 (A16), U15.33 (A16), U16.33 (A16), U27.3
/MA17: U1.34 (A17), U2.34 (A17), U3.34 (A17), U4.34 (A17), U5.34 (A17), U6.34 (A17), U7.34 (A17), U8.34 (A17), U9.34 (A17), U10.34 (A17), U11.34 (A17), U12.34 (A17), U13.34 (A17), U14.34 (A17), U15.34 (A17), U16.34 (A17), U27.6
/MA18: U1.35 (A18), U2.35 (A18), U3.35 (A18), U4.35 (A18), U5.35 (A18), U6.35 (A18), U7.35 (A18), U8.35 (A18), U9.35 (A18), U10.35 (A18), U11.35 (A18), U12.35 (A18), U13.35 (A18), U14.35 (A18), U15.35 (A18), U16.35 (A18), U27.8
/MD0: U1.7 (I/O0), U2.7 (I/O0), U3.7 (I/O0), U4.7 (I/O0), U5.7 (I/O0), U6.7 (I/O0), U7.7 (I/O0), U8.7 (I/O0), U18.18 (1Y0), U19.2 (I0a)
/MD1: U1.8 (I/O1), U2.8 (I/O1), U3.8 (I/O1), U4.8 (I/O1), U5.8 (I/O1), U6.8 (I/O1), U7.8 (I/O1), U8.8 (I/O1), U18.16 (1Y1), U19.5 (I0b)
/MD2: U1.11 (I/O2), U2.11 (I/O2), U3.11 (I/O2), U4.11 (I/O2), U5.11 (I/O2), U6.11 (I/O2), U7.11 (I/O2), U8.11 (I/O2), U18.14 (1Y2), U19.14 (I0c)
/MD3: U1.12 (I/O3), U2.12 (I/O3), U3.12 (I/O3), U4.12 (I/O3), U5.12 (I/O3), U6.12 (I/O3), U7.12 (I/O3), U8.12 (I/O3), U18.12 (1Y3), U19.11 (I0d)
/MD4: U1.25 (I/O4), U2.25 (I/O4), U3.25 (I/O4), U4.25 (I/O4), U5.25 (I/O4), U6.25 (I/O4), U7.25 (I/O4), U8.25 (I/O4), U18.3 (2Y0), U25.2 (I0a)
/MD5: U1.26 (I/O5), U2.26 (I/O5), U3.26 (I/O5), U4.26 (I/O5), U5.26 (I/O5), U6.26 (I/O5), U7.26 (I/O5), U8.26 (I/O5), U18.5 (2Y1), U25.5 (I0b)
/MD6: U1.29 (I/O6), U2.29 (I/O6), U3.29 (I/O6), U4.29 (I/O6), U5.29 (I/O6), U6.29 (I/O6), U7.29 (I/O6), U8.29 (I/O6), U18.7 (2Y2), U25.14 (I0c)
/MD7: U1.30 (I/O7), U2.30 (I/O7), U3.30 (I/O7), U4.30 (I/O7), U5.30 (I/O7), U6.30 (I/O7), U7.30 (I/O7), U8.30 (I/O7), U18.9 (2Y3), U25.11 (I0d)
/MD8: U9.7 (I/O0), U10.7 (I/O0), U11.7 (I/O0), U12.7 (I/O0), U13.7 (I/O0), U14.7 (I/O0), U15.7 (I/O0), U16.7 (I/O0), U19.3 (I1a), U20.4 (Za), U24.2 (1A0)
/MD9: U9.8 (I/O1), U10.8 (I/O1), U11.8 (I/O1), U12.8 (I/O1), U13.8 (I/O1), U14.8 (I/O1), U15.8 (I/O1), U16.8 (I/O1), U19.6 (I1b), U20.7 (Zb), U24.4 (1A1)
/MD10: U9.11 (I/O2), U10.11 (I/O2), U11.11 (I/O2), U12.11 (I/O2), U13.11 (I/O2), U14.11 (I/O2), U15.11 (I/O2), U16.11 (I/O2), U19.13 (I1c), U20.12 (Zc), U24.6 (1A2)
/MD11: U9.12 (I/O3), U10.12 (I/O3), U11.12 (I/O3), U12.12 (I/O3), U13.12 (I/O3), U14.12 (I/O3), U15.12 (I/O3), U16.12 (I/O3), U19.10 (I1d), U20.9 (Zd), U24.8 (1A3)
/MD12: U9.25 (I/O4), U10.25 (I/O4), U11.25 (I/O4), U12.25 (I/O4), U13.25 (I/O4), U14.25 (I/O4), U15.25 (I/O4), U16.25 (I/O4), U24.17 (2A0), U25.3 (I1a), U26.4 (Za)
/MD13: U9.26 (I/O5), U10.26 (I/O5), U11.26 (I/O5), U12.26 (I/O5), U13.26 (I/O5), U14.26 (I/O5), U15.26 (I/O5), U16.26 (I/O5), U24.15 (2A1), U25.6 (I1b), U26.7 (Zb)
/MD14: U9.29 (I/O6), U10.29 (I/O6), U11.29 (I/O6), U12.29 (I/O6), U13.29 (I/O6), U14.29 (I/O6), U15.29 (I/O6), U16.29 (I/O6), U24.13 (2A2), U25.13 (I1c), U26.12 (Zc)
/MD15: U9.30 (I/O7), U10.30 (I/O7), U11.30 (I/O7), U12.30 (I/O7), U13.30 (I/O7), U14.30 (I/O7), U15.30 (I/O7), U16.30 (I/O7), U24.11 (2A3), U25.10 (I1d), U26.9 (Zd)
/SEL: U19.1 (S), U20.1 (S), U22.12 (IO8), U25.1 (S), U26.1 (S)
/~BHE: J1.37 (BHE), U22.3 (I3)
/~BRDSEL: U22.13 (IO7), U27.13
/~CS0: U1.6 (~CE), U9.6 (~CE), U21.15 (Y0)
/~CS1: U2.6 (~CE), U10.6 (~CE), U21.14 (Y1)
/~CS2: U3.6 (~CE), U11.6 (~CE), U21.13 (Y2)
/~CS3: U4.6 (~CE), U12.6 (~CE), U21.12 (Y3)
/~CS4: U5.6 (~CE), U13.6 (~CE), U21.11 (Y4)
/~CS5: U6.6 (~CE), U14.6 (~CE), U21.10 (Y5)
/~CS6: U7.6 (~CE), U15.6 (~CE), U21.9 (Y6)
/~CS7: U8.6 (~CE), U16.6 (~CE), U21.7 (Y7)
/~M16: J1.36 (M16), JP3.2, U27.11
/~MEMR: J1.32 (MEMR), U22.5 (I5)
/~MEMW: J1.33 (MEMW), U22.6 (I6)
/~MOVL: J1.34 (MOVL), JP1.1, JP3.1
/~OEH: U9.31 (~OE), U10.31 (~OE), U11.31 (~OE), U12.31 (~OE), U13.31 (~OE), U14.31 (~OE), U15.31 (~OE), U16.31 (~OE), U22.18 (IO2)
/~OEL: U1.31 (~OE), U2.31 (~OE), U3.31 (~OE), U4.31 (~OE), U5.31 (~OE), U6.31 (~OE), U7.31 (~OE), U8.31 (~OE), U22.19 (IO1)
/~RD: U19.15 (OE), U22.15 (IO5), U24.1 (1OE), U24.19 (2OE), U25.15 (OE)
/~WEH: U9.13 (~WE), U10.13 (~WE), U11.13 (~WE), U12.13 (~WE), U13.13 (~WE), U14.13 (~WE), U15.13 (~WE), U16.13 (~WE), U22.16 (IO4)
/~WEL: U1.13 (~WE), U2.13 (~WE), U3.13 (~WE), U4.13 (~WE), U5.13 (~WE), U6.13 (~WE), U7.13 (~WE), U8.13 (~WE), U22.17 (I03)
/~WR: U18.1 (1OE), U18.19 (2OE), U20.15 (OE), U22.14 (IO6), U26.15 (OE)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, J1.1 (GND), J1.2 (GND), J1.3 (GND), J1.4 (GND), J1.5 (GND), J1.116 (GND), J1.117 (GND), J1.118 (GND), J1.119 (GND), J1.120 (GND), J1.121, J1.122, JP2.1, U1.10 (GND), U1.28 (GND), U2.10 (GND), U2.28 (GND), U3.10 (GND), U3.28 (GND), U4.10 (GND), U4.28 (GND), U5.10 (GND), U5.28 (GND), U6.10 (GND), U6.28 (GND), U7.10 (GND), U7.28 (GND), U8.10 (GND), U8.28 (GND), U9.10 (GND), U9.28 (GND), U10.10 (GND), U10.28 (GND), U11.10 (GND), U11.28 (GND), U12.10 (GND), U12.28 (GND), U13.10 (GND), U13.28 (GND), U14.10 (GND), U14.28 (GND), U15.10 (GND), U15.28 (GND), U16.10 (GND), U16.28 (GND), U17.1 (1OE), U17.10 (GND), U17.19 (2OE), U18.10 (GND), U19.8 (GND), U20.8 (GND)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
unnamed: JP1.2, U22.4 (I4)
unnamed: JP2.2, U22.7 (I7)

Board: 2 copper layers, 100.0 x 100.0 mm, 60 parts (16 on the bottom side), 100 nets.

## KiCad design Boards/PPR Board/PPR Board.kicad_pcb

Parts:
BT1: CR2032; BatteryHolder_Keystone_103_1x20mm
C1: 33uF; CP_Tantalum_Case-B_EIA-3528-21_Hand
C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: .1uF; C_0805_HandSoldering
J1: CheapBusTX24-RA; JAE_TX24-120R-LT-H1E; Mouser Part Number 656-TX24120RLTH1E
J2: INT; DIP-16_W7.62mm
J3: RTC RST; Pin_Header_Straight_1x03_Pitch2.54mm
J4: Crystal; Pin_Header_Straight_1x01_Pitch1.00mm
J5: mounts; Pin_Header_Straight_1x01_Pitch1.00mm
JP1: VBAT; Pin_Header_Straight_1x02_Pitch2.54mm
JP2: CLR RTC; Pin_Header_Straight_1x02_Pitch2.54mm
RN1, RN3: 10k; R_Array_SIP6
RN2: 10k; R_Array_SIP10
SW1: HI ADDR; SW_DIP_x8_W7.62mm_Slide
SW2: LOW ADDR; SW_DIP_x4_W7.62mm_Slide
U1: 82C54_PLCC; PLCC28
U2: 74HCT245; SOIC-20W_7.5x12.8mm_Pitch1.27mm
U3: 22V10-PLCC; PLCC28
U4: 74LS06; SOIC-14_3.9x8.7mm_Pitch1.27mm
U5: 74HCT244; SOIC-20W_7.5x12.8mm_Pitch1.27mm
U6: 8259A; PLCC28
U7: 74HCT688; SOIC-20W_7.5x12.8mm_Pitch1.27mm
U8: 74HCT240; SOIC-20W_7.5x12.8mm_Pitch1.27mm
U9: 74HCT85; SOIC-16_3.9x9.9mm_Pitch1.27mm
U10: DS12885Q; PLCC28
X1: 2MHz; Oscillator_DIP-8
Y1: 32768Hz; Crystal_C26-LF_d2.1mm_l6.5mm_Horizontal

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, J1.58 (5V), J1.59 (5V), J1.60 (5V), J1.61 (5V), J1.62 (5V), J3.1, RN1.1 (common), SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW1.15, SW1.16, SW2.5, SW2.6, SW2.7, SW2.8, U1.13 (G0), U1.17 (G1), U1.19 (G2), U1.28 (VCC), U2.20 (VCC), U3.1 (VCC), U3.28 (VCC), U4.14 (VCC), U5.20 (VCC), U6.28 (VCC), U7.20 (VCC), U8.20 (VCC), U9.3 (Ia=b), U9.16 (VCC), U10.28 (VCC), X1.8 (Vcc)
/A0: U1.22 (A0), U3.7 (I6), U5.3 (2Y0), U6.27 (A0)
/A1: U1.23 (A1), U3.6 (I5), U5.5 (2Y1)
/A2: U3.5 (I4), U5.7 (2Y2)
/A3: U3.4 (I3), U5.9 (2Y3)
/A4: J1.25 (A4), U9.10 (A0)
/A5: J1.24 (A5), U9.12 (A1)
/A6: J1.23 (A6), U9.13 (A2)
/A7: J1.22 (A7), U9.15 (A3)
/A8: J1.21 (A8), U7.17 (P7)
/A9: J1.20 (A9), U7.15 (P6)
/A10: J1.19 (A10), U7.13 (P5)
/A11: J1.18 (A11), U7.11 (P4)
/A12: J1.17 (A12), U7.8 (P3)
/A13: J1.16 (A13), U7.6 (P2)
/A14: J1.15 (A14), U7.4 (P1)
/A15: J1.14 (A15), U7.2 (P0)
/D0: U1.9 (D0), U2.2 (A0), U6.11 (D0), U10.5 (AD0)
/D1: U1.8 (D1), U2.3 (A1), U6.10 (D1), U10.6 (AD1)
/D2: U1.7 (D2), U2.4 (A2), U6.9 (D2), U10.7 (AD2)
/D3: U1.6 (D3), U2.5 (A3), U6.8 (D3), U10.8 (AD3)
/D4: U1.5 (D4), U2.6 (A4), U6.7 (D4), U10.9 (AD4)
/D5: U1.4 (D5), U2.7 (A5), U6.6 (D5), U10.10 (AD5)
/D6: U1.3 (D6), U2.8 (A6), U6.5 (D6), U10.12 (AD6)
/D7: U1.2 (D7), U2.9 (A7), U6.4 (D7), U10.14 (AD7)
/DDIR: U2.1 (A->B), U3.25 (O3)
/INT: U3.12 (I10), U6.17 (INT)
/LOM: U3.3 (I2), U9.6 (Oa=b)
/PU0: RN1.6 (R5), U6.16 (~SP~/~EN~)
/PU1: J2.7, RN1.5 (R4), U4.1, U4.4
/PU2: J2.5, RN1.4 (R3), U4.5, U4.8
/PU3: J2.3, RN1.3 (R2), U4.11, U4.12
/RTC_AS: U3.18 (O9), U10.17 (AS)
/SQW: U5.8 (1A3), U10.27 (SQW)
/T0: U1.12 (OUT0), U4.3, U5.2 (1A0)
/T1: U1.16 (OUT1), U4.9, U5.4 (1A1)
/T2: U1.20 (OUT2), U4.13, U5.6 (1A2)
/VBAT: J1.55 (VBAT), JP1.2
/bA0: J1.29 (A0), U5.17 (2A0)
/bA1: J1.28 (A1), U5.15 (2A1)
/bA2: J1.27 (A2), U5.13 (2A2)
/bA3: J1.26 (A3), U5.11 (2A3)
/bD0: J1.81 (D0), U2.18 (B0)
/bD1: J1.80 (D1), U2.17 (B1)
/bD2: J1.79 (D2), U2.16 (B2)
/bD3: J1.78 (D3), U2.15 (B3)
/bD4: J1.77 (D4), U2.14 (B4), U5.18 (1Y0)
/bD5: J1.76 (D5), U2.13 (B5), U5.16 (1Y1)
/bD6: J1.75 (D6), U2.12 (B6), U5.14 (1Y2)
/bD7: J1.74 (D7), U2.11 (B7), U5.12 (1Y3)
/~AEN: J1.90 (AEN), U3.9 (I7)
/~HIM: U3.2 (I1/CLK), U7.19 (P=R)
/~INT: J1.100 (INT), U3.26 (O2)
/~IOR: J1.30 (IOR), U3.10 (I8)
/~IOW: J1.31 (IOW), U3.11 (I9)
/~IRQ0: J1.109 (IRQ0), J2.9, U8.11 (2A3)
/~IRQ1: J1.108 (IRQ1), J2.10, U8.13 (2A2)
/~IRQ2: J1.107 (IRQ2), J2.11, U8.15 (2A1)
/~IRQ3: J1.106 (IRQ3), J2.12, U8.17 (2A0)
/~IRQ4: J1.105 (IRQ4), J2.13, U8.8 (1A3)
/~IRQ5: J1.104 (IRQ5), J2.14, U8.6 (1A2)
/~IRQ6: J1.103 (IRQ6), J2.15, U8.4 (1A1)
/~IRQ7: J1.102 (IRQ7), J2.16, U8.2 (1A0)
/~PIC_CS: U3.20 (O7), U6.1 (~CS~)
/~PIT_CS: U1.24 (~CS~), U3.17 (O10)
/~RESET: J1.115 (RESET), J3.3
/~RTCI: J2.2, U10.23 (~IRQ)
/~RTC_CS: U3.19 (O8), U10.16 (~CS)
/~STS: U3.21 (O6), U5.1 (1OE)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J1.1 (GND), J1.2 (GND), J1.3 (GND), J1.4 (GND), J1.5 (GND), J1.116 (GND), J1.117 (GND), J1.118 (GND), J1.119 (GND), J1.120 (GND), J1.121, J1.122, J4.1, J5.1, JP2.2, RN2.1 (common), RN3.1 (common), U1.14 (GND), U2.10 (GND), U2.19 (CE), U3.8 (GND), U3.14 (GND), U3.15 (GND), U3.22 (GND), U4.7 (GND), U5.10 (GND), U5.19 (2OE), U6.14 (GND), U7.1 (G), U7.10 (GND), U8.1 (1OE), U8.10 (GND), U8.19 (2OE), U9.2 (Ia<b), U9.4 (Ia>b), U9.8 (GND), U10.15 (GND), U10.20 (GND), X1.4 (GND)
unnamed: BT1.1 (+), JP1.1, U10.24 (VBAT)
unnamed: J2.4, U4.10
unnamed: J2.6, U4.6
unnamed: J2.8, U4.2
unnamed: J3.2, U10.22 (~RESET)
unnamed: JP2.1, U10.25 (~RCLR)
unnamed: RN2.3 (R2), SW1.1, U7.3 (R0)
unnamed: RN2.4 (R3), SW1.2, U7.5 (R1)
unnamed: RN2.5 (R4), SW1.3, U7.7 (R2)
unnamed: RN2.6 (R5), SW1.4, U7.9 (R3)
unnamed: RN2.7 (R6), SW1.5, U7.12 (R4)
unnamed: RN2.8 (R7), SW1.6, U7.14 (R5)
unnamed: RN2.9 (R8), SW1.7, U7.16 (R6)
unnamed: RN2.10 (R9), SW1.8, U7.18 (R7)
unnamed: RN3.3 (R2), SW2.4, U9.9 (B0)
unnamed: RN3.4 (R3), SW2.3, U9.11 (B1)
unnamed: RN3.5 (R4), SW2.2, U9.14 (B2)
unnamed: RN3.6 (R5), SW2.1, U9.1 (B3)
unnamed: U1.10 (CLK0), U1.18 (CLK1), U1.21 (CLK2), X1.5 (OUT)
unnamed: U6.18 (IR0), U8.9 (2Y3)
unnamed: U6.19 (IR1), U8.7 (2Y2)
unnamed: U6.20 (IR2), U8.5 (2Y1)
unnamed: U6.21 (IR3), U8.3 (2Y0)
unnamed: U6.22 (IR4), U8.12 (1Y3)
unnamed: U6.23 (IR5), U8.14 (1Y2)
unnamed: U6.24 (IR6), U8.16 (1Y1)
unnamed: U6.25 (IR7), U8.18 (1Y0)
unnamed: U10.3 (X1), Y1.2
unnamed: U10.4 (X2), Y1.1

Notes on the sheet:
6pF

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