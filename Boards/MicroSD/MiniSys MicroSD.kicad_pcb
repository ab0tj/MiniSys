# Repository ab0tj/MiniSys (continued)

## KiCad design Boards/Backplane/MiniSys-Backplane.kicad_pcb

Parts:
C1, C4, C6, C8, C10, C12, C14, C16, C18, C20, C26, C27, C28, C29, C30, C31, C33, C35, C37, C39, C41, C45: .1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3, C5, C7, C9, C11, C13, C15, C17, C19, C21, C23, C25, C32, C34, C36, C38, C40, C42, C43, C44: 33uF; CP_Radial_Tantal_D6.0mm_P2.50mm
C46: .47uF; CP_Radial_Tantal_D4.5mm_P2.50mm
D3: PWR; LED_D5.0mm
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: TX25-120P-6ST-H1E; JAE_TX25-120P-6ST-H1E; Mouser Part Number 656-TX25120P6STH1E
J13: ATX24; ATX-24PIN
J14: PWR; Pin_Header_Straight_1x02_Pitch2.54mm
J15: RST; Pin_Header_Straight_1x02_Pitch2.54mm
J16, J17, J18, J19, J20: Conn_01x01_Female; 1pin
J21: Mounting holes; 1pin
J22: PLED; Pin_Header_Straight_1x02_Pitch2.54mm
J23: ISP; Pin_Header_Straight_2x03_Pitch2.54mm
J24: BATT; Pin_Header_Straight_1x02_Pitch2.54mm
J25: DBG; Pin_Header_Straight_1x02_Pitch2.54mm
JP1: 5V 12V; Pin_Header_Straight_1x03_Pitch2.54mm
LOGO1: Logo_Open_Hardware_Large; OSHW-Logo_7.5x8mm_SilkScreen
Q1: 2N3906; TO-92_Inline_Narrow_Oval
Q2: 2N3904; TO-92_Inline_Narrow_Oval
Q3: TIP29; TO-220-3_Horizontal
Q4: TIP30; TO-220-3_Horizontal
R1, R2, R15, R16, R18, R22: 2200; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 4700; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5: 1800; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R7: 560; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 150K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R12, R20: 1000; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10, R11: 910; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13, R14: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17, R19, R21: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R23: 20M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R24: 7.5M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10, RN11, RN13, RN14, RN15, RN16, RN17, RN18, RN19, RN20, RN21, RN23, RN24: 560; R_Array_SIP10
RV1: 2000; Potentiometer_Trimmer_Bourns_3296W
SW1: PWR; SW_PUSH_6mm_h5mm
SW2: RST; SW_PUSH_6mm_h5mm
SW3: DEBUG; SW_PUSH_6mm_h5mm
U1: ATtiny861A-PU; DIP-20_W7.62mm
U2: DS18B20; TO-92_Inline_Narrow_Oval
U4: L78L05_TO92; TO-92_Inline_Narrow_Oval
U5: LM4250; DIP-8_W7.62mm

Connections:
+2V8: C26.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, Q3.3 (E), Q4.3 (E), R9.1, R10.2, R11.1, R12.1, RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), RN6.1 (common), RN7.1 (common), RN8.1 (common), RN9.1 (common), RN10.1 (common), RN11.1 (common), RN13.1 (common), RN14.1 (common), RN15.1 (common), RN16.1 (common), RN17.1 (common), RN18.1 (common), RN19.1 (common), RN20.1 (common), RN21.1 (common), RN23.1 (common), RN24.1 (common), U5.6
+5V: C7.1, C8.2, C9.1, C10.2, C11.1, C12.2, C13.1, C14.2, C15.1, C16.2, C17.1, C18.2, C19.1, C20.2, C21.1, C23.1, C25.1, J1.58, J1.59, J1.60, J1.61, J1.62, J2.58, J2.59, J2.60, J2.61, J2.62, J3.58, J3.59, J3.60, J3.61, J3.62, J4.58, J4.59, J4.60, J4.61, J4.62, J5.58, J5.59, J5.60, J5.61, J5.62, J6.58, J6.59, J6.60, J6.61, J6.62, J7.58, J7.59, J7.60, J7.61, J7.62, J8.58, J8.59, J8.60, J8.61, J8.62, J9.58, J9.59, J9.60, J9.61, J9.62, J10.58, J10.59, J10.60, J10.61, J10.62, J11.58, J11.59, J11.60, J11.61, J11.62, J12.58, J12.59, J12.60, J12.61, J12.62, J13.4 (5V), J13.6 (5V), J13.21 (5V)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
+12V: C27.2, C43.1, J1.65, J2.65, J3.65, J4.65, J5.65, J6.65, J7.65, J8.65, J9.65, J10.65, J11.65, J12.65, J13.10 (12V), J13.11 (12V), JP1.3 (B), R3.1, U4.3 (VI)
-12V: C28.2, J1.56, J2.56, J3.56, J4.56, J5.56, J6.56, J7.56, J8.56, J9.56, J10.56, J11.56, J12.56, J13.14 (-12)
/+3.3V: C3.1, C4.2, C5.1, C6.2, J1.57, J1.64, J2.57, J2.64, J3.57, J3.64, J4.57, J4.64, J5.57, J5.64, J6.57, J6.64, J7.57, J7.64, J8.57, J8.64, J9.57, J9.64, J10.57, J10.64, J11.57, J11.64, J12.57, J12.64, J13.1 (3V3), J13.2 (3V3), J13.12 (3V3), J13.13 (3V3), R20.1
/+5VSB: C29.2, C30.2, C31.2, J1.63, J2.63, J3.63, J4.63, J5.63, J6.63, J7.63, J8.63, J9.63, J10.63, J11.63, J12.63, J13.9 (5VSB), J23.2, R1.1, R2.1, R15.1, R16.1, R22.1, U1.5 (VCC), U1.15 (AVCC), U2.3 (VDD)
/-5V: J13.20 (-5V)
/M3V3: R20.2, R21.1, U1.14 (PA4)
/M5: R18.2, R19.1, U1.13 (PA5)
/M12: R3.2, R17.1, U1.12 (PA6)
/MBAT: C1.1, R23.2, R24.1, U1.11 (PA7)
/POK: J13.8 (POK), U1.17 (AREF/PA3)
/S0: J1.10, J2.10, J3.10, J4.10, J5.10, J6.10, J7.10, J8.10, J9.10, J10.10, J11.10, J12.10, RN3.4 (R3), RN15.4 (R3)
/S1: J1.11, J2.11, J3.11, J4.11, J5.11, J6.11, J7.11, J8.11, J9.11, J10.11, J11.11, J12.11, RN1.4 (R3), RN13.4 (R3)
/S2: J1.12, J2.12, J3.12, J4.12, J5.12, J6.12, J7.12, J8.12, J9.12, J10.12, J11.12, J12.12, RN3.5 (R4), RN15.5 (R4)
/S3: J1.13, J2.13, J3.13, J4.13, J5.13, J6.13, J7.13, J8.13, J9.13, J10.13, J11.13, J12.13, RN1.5 (R4), RN13.5 (R4)
/S4: J1.14, J2.14, J3.14, J4.14, J5.14, J6.14, J7.14, J8.14, J9.14, J10.14, J11.14, J12.14, RN3.6 (R5), RN15.6 (R5)
/S5: J1.15, J2.15, J3.15, J4.15, J5.15, J6.15, J7.15, J8.15, J9.15, J10.15, J11.15, J12.15, RN1.6 (R5), RN13.6 (R5)
/S6: J1.16, J2.16, J3.16, J4.16, J5.16, J6.16, J7.16, J8.16, J9.16, J10.16, J11.16, J12.16, RN3.7 (R6), RN15.7 (R6)
/S7: J1.17, J2.17, J3.17, J4.17, J5.17, J6.17, J7.17, J8.17, J9.17, J10.17, J11.17, J12.17, RN1.7 (R6), RN13.7 (R6)
/S8: J1.18, J2.18, J3.18, J4.18, J5.18, J6.18, J7.18, J8.18, J9.18, J10.18, J11.18, J12.18, RN3.8 (R7), RN15.8 (R7)
/S9: J1.19, J2.19, J3.19, J4.19, J5.19, J6.19, J7.19, J8.19, J9.19, J10.19, J11.19, J12.19, RN1.8 (R7), RN13.8 (R7)
/S10: J1.20, J2.20, J3.20, J4.20, J5.20, J6.20, J7.20, J8.20, J9.20, J10.20, J11.20, J12.20, RN3.9 (R8), RN15.9 (R8)
/S11: J1.21, J2.21, J3.21, J4.21, J5.21, J6.21, J7.21, J8.21, J9.21, J10.21, J11.21, J12.21, RN1.9 (R8), RN13.9 (R8)
/S12: J1.22, J2.22, J3.22, J4.22, J5.22, J6.22, J7.22, J8.22, J9.22, J10.22, J11.22, J12.22, RN3.10 (R9), RN15.10 (R9)
/S13: J1.23, J2.23, J3.23, J4.23, J5.23, J6.23, J7.23, J8.23, J9.23, J10.23, J11.23, J12.23, RN1.10 (R9), RN13.10 (R9)
/S14: J1.24, J2.24, J3.24, J4.24, J5.24, J6.24, J7.24, J8.24, J9.24, J10.24, J11.24, J12.24, RN4.2 (R1), RN16.2 (R1)
/S15: J1.25, J2.25, J3.25, J4.25, J5.25, J6.25, J7.25, J8.25, J9.25, J10.25, J11.25, J12.25, RN2.2 (R1), RN14.2 (R1)
/S16: J1.26, J2.26, J3.26, J4.26, J5.26, J6.26, J7.26, J8.26, J9.26, J10.26, J11.26, J12.26, RN4.3 (R2), RN16.3 (R2)
/S17: J1.27, J2.27, J3.27, J4.27, J5.27, J6.27, J7.27, J8.27, J9.27, J10.27, J11.27, J12.27, RN2.3 (R2), RN14.3 (R2)
/S18: J1.28, J2.28, J3.28, J4.28, J5.28, J6.28, J7.28, J8.28, J9.28, J10.28, J11.28, J12.28, RN4.4 (R3), RN16.4 (R3)
/S19: J1.29, J2.29, J3.29, J4.29, J5.29, J6.29, J7.29, J8.29, J9.29, J10.29, J11.29, J12.29, RN2.4 (R3), RN14.4 (R3)
/S20: J1.30, J2.30, J3.30, J4.30, J5.30, J6.30, J7.30, J8.30, J9.30, J10.30, J11.30, J12.30, RN4.5 (R4), RN16.5 (R4)
/S21: J1.31, J2.31, J3.31, J4.31, J5.31, J6.31, J7.31, J8.31, J9.31, J10.31, J11.31, J12.31, RN2.5 (R4), RN14.5 (R4)
/S22: J1.32, J2.32, J3.32, J4.32, J5.32, J6.32, J7.32, J8.32, J9.32, J10.32, J11.32, J12.32, RN4.6 (R5), RN16.6 (R5)
/S23: J1.33, J2.33, J3.33, J4.33, J5.33, J6.33, J7.33, J8.33, J9.33, J10.33, J11.33, J12.33, RN2.6 (R5), RN14.6 (R5)
/S24: J1.34, J2.34, J3.34, J4.34, J5.34, J6.34, J7.34, J8.34, J9.34, J10.34, J11.34, J12.34, RN4.7 (R6), RN16.7 (R6)
/S25: J1.35, J2.35, J3.35, J4.35, J5.35, J6.35, J7.35, J8.35, J9.35, J10.35, J11.35, J12.35, RN2.7 (R6), RN14.7 (R6)
/S26: J1.36, J2.36, J3.36, J4.36, J5.36, J6.36, J7.36, J8.36, J9.36, J10.36, J11.36, J12.36, RN4.8 (R7), RN16.8 (R7)
/S27: J1.37, J2.37, J3.37, J4.37, J5.37, J6.37, J7.37, J8.37, J9.37, J10.37, J11.37, J12.37, RN2.8 (R7), RN14.8 (R7)
/S28: J1.38, J2.38, J3.38, J4.38, J5.38, J6.38, J7.38, J8.38, J9.38, J10.38, J11.38, J12.38, RN4.9 (R8), RN16.9 (R8)
/S29: J1.39, J2.39, J3.39, J4.39, J5.39, J6.39, J7.39, J8.39, J9.39, J10.39, J11.39, J12.39, RN2.9 (R8), RN14.9 (R8)
/S30: J1.40, J2.40, J3.40, J4.40, J5.40, J6.40, J7.40, J8.40, J9.40, J10.40, J11.40, J12.40, RN4.10 (R9), RN16.10 (R9)
/S31: J1.41, J2.41, J3.41, J4.41, J5.41, J6.41, J7.41, J8.41, J9.41, J10.41, J11.41, J12.41, RN2.10 (R9), RN14.10 (R9)
/S32: J1.42, J2.42, J3.42, J4.42, J5.42, J6.42, J7.42, J8.42, J9.42, J10.42, J11.42, J12.42, RN10.2 (R1), RN24.2 (R1)
/S33: J1.43, J2.43, J3.43, J4.43, J5.43, J6.43, J7.43, J8.43, J9.43, J10.43, J11.43, J12.43, RN10.3 (R2), RN24.3 (R2)
/S34: J1.44, J2.44, J3.44, J4.44, J5.44, J6.44, J7.44, J8.44, J9.44, J10.44, J11.44, J12.44, RN5.3 (R2), RN17.3 (R2)
/S35: J1.45, J2.45, J3.45, J4.45, J5.45, J6.45, J7.45, J8.45, J9.45, J10.45, J11.45, J12.45, RN10.4 (R3), RN24.4 (R3)
/S36: J1.46, J2.46, J3.46, J4.46, J5.46, J6.46, J7.46, J8.46, J9.46, J10.46, J11.46, J12.46, RN5.5 (R4), RN17.5 (R4)
/S37: J1.47, J2.47, J3.47, J4.47, J5.47, J6.47, J7.47, J8.47, J9.47, J10.47, J11.47, J12.47, RN10.5 (R4), RN24.5 (R4)
/S38: J1.48, J2.48, J3.48, J4.48, J5.48, J6.48, J7.48, J8.48, J9.48, J10.48, J11.48, J12.48, RN10.6 (R5), RN24.6 (R5)
/S39: J1.49, J2.49, J3.49, J4.49, J5.49, J6.49, J7.49, J8.49, J9.49, J10.49, J11.49, J12.49, RN10.7 (R6), RN24.7 (R6)
/S40: J1.50, J2.50, J3.50, J4.50, J5.50, J6.50, J7.50, J8.50, J9.50, J10.50, J11.50, J12.50, RN5.7 (R6), RN17.7 (R6)
/S41: J1.51, J2.51, J3.51, J4.51, J5.51, J6.51, J7.51, J8.51, J9.51, J10.51, J11.51, J12.51, RN10.8 (R7), RN24.8 (R7)
/S42: J1.52, J2.52, J3.52, J4.52, J5.52, J6.52, J7.52, J8.52, J9.52, J10.52, J11.52, J12.52
/S43: J1.53, J2.53, J3.53, J4.53, J5.53, J6.53, J7.53, J8.53, J9.53, J10.53, J11.53, J12.53
/S44: J1.54, J2.54, J3.54, J4.54, J5.54, J6.54, J7.54, J8.54, J9.54, J10.54, J11.54, J12.54
/S48: J1.9, J2.9, J3.9, J4.9, J5.9, J6.9, J7.9, J8.9, J9.9, J10.9, J11.9, J12.9, RN1.3 (R2), RN13.3 (R2)
/S49: J1.6, J2.6, J3.6, J4.6, J5.6, J6.6, J7.6, J8.6, J9.6, J10.6, J11.6, J12.6, RN3.2 (R1), RN15.2 (R1)
/S50: J1.7, J2.7, J3.7, J4.7, J5.7, J6.7, J7.7, J8.7, J9.7, J10.7, J11.7, J12.7, RN1.2 (R1), RN13.2 (R1)
/S51: J1.8, J2.8, J3.8, J4.8, J5.8, J6.8, J7.8, J8.8, J9.8, J10.8, J11.8, J12.8, RN3.3 (R2), RN15.3 (R2)
/S52: J1.66, J2.66, J3.66, J4.66, J5.66, J6.66, J7.66, J8.66, J9.66, J10.66, J11.66, J12.66, RN8.2 (R1), RN20.2 (R1)
/S53: J1.67, J2.67, J3.67, J4.67, J5.67, J6.67, J7.67, J8.67, J9.67, J10.67, J11.67, J12.67, RN6.2 (R1), RN18.2 (R1)
/S54: J1.68, J2.68, J3.68, J4.68, J5.68, J6.68, J7.68, J8.68, J9.68, J10.68, J11.68, J12.68, RN8.3 (R2), RN20.3 (R2)
/S55: J1.69, J2.69, J3.69, J4.69, J5.69, J6.69, J7.69, J8.69, J9.69, J10.69, J11.69, J12.69, RN6.3 (R2), RN18.3 (R2)
/S56: J1.70, J2.70, J3.70, J4.70, J5.70, J6.70, J7.70, J8.70, J9.70, J10.70, J11.70, J12.70, RN8.4 (R3), RN20.4 (R3)
/S57: J1.71, J2.71, J3.71, J4.71, J5.71, J6.71, J7.71, J8.71, J9.71, J10.71, J11.71, J12.71, RN6.4 (R3), RN18.4 (R3)
/S58: J1.72, J2.72, J3.72, J4.72, J5.72, J6.72, J7.72, J8.72, J9.72, J10.72, J11.72, J12.72, RN8.5 (R4), RN20.5 (R4)
/S59: J1.73, J2.73, J3.73, J4.73, J5.73, J6.73, J7.73, J8.73, J9.73, J10.73, J11.73, J12.73, RN6.5 (R4), RN18.5 (R4)
/S60: J1.74, J2.74, J3.74, J4.74, J5.74, J6.74, J7.74, J8.74, J9.74, J10.74, J11.74, J12.74, RN8.6 (R5), RN20.6 (R5)
/S61: J1.75, J2.75, J3.75, J4.75, J5.75, J6.75, J7.75, J8.75, J9.75, J10.75, J11.75, J12.75, RN6.6 (R5), RN18.6 (R5)
/S62: J1.76, J2.76, J3.76, J4.76, J5.76, J6.76, J7.76, J8.76, J9.76, J10.76, J11.76, J12.76, RN8.7 (R6), RN20.7 (R6)
/S63: J1.77, J2.77, J3.77, J4.77, J5.77, J6.77, J7.77, J8.77, J9.77, J10.77, J11.77, J12.77, RN6.7 (R6), RN18.7 (R6)
/S64: J1.78, J2.78, J3.78, J4.78, J5.78, J6.78, J7.78, J8.78, J9.78, J10.78, J11.78, J12.78, RN8.8 (R7), RN20.8 (R7)
/S65: J1.79, J2.79, J3.79, J4.79, J5.79, J6.79, J7.79, J8.79, J9.79, J10.79, J11.79, J12.79, RN6.8 (R7), RN18.8 (R7)
/S66: J1.80, J2.80, J3.80, J4.80, J5.80, J6.80, J7.80, J8.80, J9.80, J10.80, J11.80, J12.80, RN8.9 (R8), RN20.9 (R8)
/S67: J1.81, J2.81, J3.81, J4.81, J5.81, J6.81, J7.81, J8.81, J9.81, J10.81, J11.81, J12.81, RN6.9 (R8), RN18.9 (R8)
/S68: J1.82, J2.82, J3.82, J4.82, J5.82, J6.82, J7.82, J8.82, J9.82, J10.82, J11.82, J12.82, RN8.10 (R9), RN20.10 (R9)
/S69: J1.83, J2.83, J3.83, J4.83, J5.83, J6.83, J7.83, J8.83, J9.83, J10.83, J11.83, J12.83, RN6.10 (R9), RN18.10 (R9)
/S70: J1.84, J2.84, J3.84, J4.84, J5.84, J6.84, J7.84, J8.84, J9.84, J10.84, J11.84, J12.84, RN11.2 (R1), RN23.2 (R1)
/S71: J1.85, J2.85, J3.85, J4.85, J5.85, J6.85, J7.85, J8.85, J9.85, J10.85, J11.85, J12.85, RN9.2 (R1), RN21.2 (R1)
/S72: J1.86, J2.86, J3.86, J4.86, J5.86, J6.86, J7.86, J8.86, J9.86, J10.86, J11.86, J12.86, RN11.3 (R2), RN23.3 (R2)
/S73: J1.87, J2.87, J3.87, J4.87, J5.87, J6.87, J7.87, J8.87, J9.87, J10.87, J11.87, J12.87, RN9.3 (R2), RN21.3 (R2)
/S74: J1.88, J2.88, J3.88, J4.88, J5.88, J6.88, J7.88, J8.88, J9.88, J10.88, J11.88, J12.88, RN11.4 (R3), RN23.4 (R3)
/S75: J1.89, J2.89, J3.89, J4.89, J5.89, J6.89, J7.89, J8.89, J9.89, J10.89, J11.89, J12.89, RN9.4 (R3), RN21.4 (R3)
/S76: J1.90, J2.90, J3.90, J4.90, J5.90, J6.90, J7.90, J8.90, J9.90, J10.90, J11.90, J12.90, RN11.5 (R4), RN23.5 (R4)
/S77: J1.91, J2.91, J3.91, J4.91, J5.91, J6.91, J7.91, J8.91, J9.91, J10.91, J11.91, J12.91, RN9.5 (R4), RN21.5 (R4)
/S78: J1.92, J2.92, J3.92, J4.92, J5.92, J6.92, J7.92, J8.92, J9.92, J10.92, J11.92, J12.92, RN11.6 (R5), RN23.6 (R5)
/S79: J1.93, J2.93, J3.93, J4.93, J5.93, J6.93, J7.93, J8.93, J9.93, J10.93, J11.93, J12.93, RN9.6 (R5), RN21.6 (R5)
/S80: J1.94, J2.94, J3.94, J4.94, J5.94, J6.94, J7.94, J8.94, J9.94, J10.94, J11.94, J12.94, RN11.7 (R6), RN23.7 (R6)
/S81: J1.95, J2.95, J3.95, J4.95, J5.95, J6.95, J7.95, J8.95, J9.95, J10.95, J11.95, J12.95, RN9.7 (R6), RN21.7 (R6)
/S82: J1.96, J2.96, J3.96, J4.96, J5.96, J6.96, J7.96, J8.96, J9.96, J10.96, J11.96, J12.96, RN11.8 (R7), RN23.8 (R7)
/S83: J1.97, J2.97, J3.97, J4.97, J5.97, J6.97, J7.97, J8.97, J9.97, J10.97, J11.97, J12.97, RN9.8 (R7), RN21.8 (R7)
/S84: J1.98, J2.98, J3.98, J4.98, J5.98, J6.98, J7.98, J8.98, J9.98, J10.98, J11.98, J12.98, RN11.9 (R8), RN23.9 (R8)
/S86: J1.100, J2.100, J3.100, J4.100, J5.100, J6.100, J7.100, J8.100, J9.100, J10.100, J11.100, J12.100, RN11.10 (R9), RN23.10 (R9)
/S87: J1.101, J2.101, J3.101, J4.101, J5.101, J6.101, J7.101, J8.101, J9.101, J10.101, J11.101, J12.101, RN9.10 (R9), RN21.10 (R9)
/S88: J1.102, J2.102, J3.102, J4.102, J5.102, J6.102, J7.102, J8.102, J9.102, J10.102, J11.102, J12.102, RN7.2 (R1), RN19.2 (R1)
/S89: J1.103, J2.103, J3.103, J4.103, J5.103, J6.103, J7.103, J8.103, J9.103, J10.103, J11.103, J12.103, RN5.2 (R1), RN17.2 (R1)
/S90: J1.104, J2.104, J3.104, J4.104, J5.104, J6.104, J7.104, J8.104, J9.104, J10.104, J11.104, J12.104, RN7.3 (R2), RN19.3 (R2)
/S91: J1.105, J2.105, J3.105, J4.105, J5.105, J6.105, J7.105, J8.105, J9.105, J10.105, J11.105, J12.105, RN5.4 (R3), RN17.4 (R3)
/S92: J1.106, J2.106, J3.106, J4.106, J5.106, J6.106, J7.106, J8.106, J9.106, J10.106, J11.106, J12.106, RN7.4 (R3), RN19.4 (R3)
/S93: J1.107, J2.107, J3.107, J4.107, J5.107, J6.107, J7.107, J8.107, J9.107, J10.107, J11.107, J12.107, RN7.5 (R4), RN19.5 (R4)
/S94: J1.108, J2.108, J3.108, J4.108, J5.108, J6.108, J7.108, J8.108, J9.108, J10.108, J11.108, J12.108, RN7.6 (R5), RN19.6 (R5)
/S95: J1.109, J2.109, J3.109, J4.109, J5.109, J6.109, J7.109, J8.109, J9.109, J10.109, J11.109, J12.109, RN5.6 (R5), RN17.6 (R5)
/S96: J1.110, J2.110, J3.110, J4.110, J5.110, J6.110, J7.110, J8.110, J9.110, J10.110, J11.110, J12.110, RN7.7 (R6), RN19.7 (R6)
/S97: J1.111, J2.111, J3.111, J4.111, J5.111, J6.111, J7.111, J8.111, J9.111, J10.111, J11.111, J12.111, RN5.8 (R7), RN17.8 (R7)
/S98: J1.112, J2.112, J3.112, J4.112, J5.112, J6.112, J7.112, J8.112, J9.112, J10.112, J11.112, J12.112, RN7.8 (R7), RN19.8 (R7)
/SCL: J1.114, J2.114, J3.114, J4.114, J5.114, J6.114, J7.114, J8.114, J9.114, J10.114, J11.114, J12.114, R16.2, U1.18 (PA2)
/SDA: J1.113, J2.113, J3.113, J4.113, J5.113, J6.113, J7.113, J8.113, J9.113, J10.113, J11.113, J12.113, R15.2, U1.20 (PA0)
/TERMPWR: JP1.2 (C), Q1.1 (E), Q3.2 (C), R7.2
/VBAT: J1.55, J2.55, J3.55, J4.55, J5.55, J6.55, J7.55, J8.55, J9.55, J10.55, J11.55, J12.55, J24.1, R23.1
/~NMI: J1.99, J2.99, J3.99, J4.99, J5.99, J6.99, J7.99, J8.99, J9.99, J10.99, J11.99, J12.99, RN9.9 (R8), RN21.9 (R8), U1.7 (XTAL1/PB4)
/~PS_ON: J13.16 (PS_ON), R1.2, U1.19 (PA1)
/~RESET: J1.115, J2.115, J3.115, J4.115, J5.115, J6.115, J7.115, J8.115, J9.115, J10.115, J11.115, J12.115, R2.2, U1.8 (XTAL2/PB5)
GND: C1.2, C3.2, C4.1, C5.2, C6.1, C7.2, C8.1, C9.2, C10.1, C11.2, C12.1, C13.2, C14.1, C15.2, C16.1, C17.2, C18.1, C19.2, C20.1, C21.2, C23.2, C25.2, C26.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, D3.1 (K), J1.1, J1.2, J1.3, J1.4, J1.5, J1.116, J1.117, J1.118, J1.119, J1.120, J2.1, J2.2, J2.3, J2.4, J2.5, J2.116, J2.117, J2.118, J2.119, J2.120, J3.1, J3.2, J3.3, J3.4, J3.5, J3.116, J3.117, J3.118, J3.119, J3.120, J4.1, J4.2, J4.3, J4.4, J4.5, J4.116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
unnamed: C44.1, C45.1, R4.2, U4.1 (VO)
unnamed: C46.1, RV1.2, U5.3 (+)
unnamed: D3.2 (A), R14.2
unnamed: J14.1, SW1.1, U1.9 (PB6)
unnamed: J15.1, J23.1, SW2.1, U1.2 (PB1)
unnamed: J22.1, R13.2
unnamed: J23.3, U1.3 (PB2)
unnamed: J23.4, J25.1, SW3.1, U1.1 (PB0)
unnamed: J23.5, R22.2, U1.10 (~RESET~/PB7)
unnamed: Q1.2 (B), R7.1, U5.7 (V+)
unnamed: Q1.3 (C), Q3.1 (B), R10.1
unnamed: Q2.2 (B), R6.1, U5.4 (V-)
unnamed: Q2.3 (C), Q4.1 (B), R11.2
unnamed: R4.1, RV1.1
unnamed: R5.1, RV1.3
unnamed: R8.1, U5.8 (IQ)
unnamed: R9.2, U5.2 (-)
unnamed: U1.4 (PB3), U2.2 (DQ)

Board: 2 copper layers, 268.6 x 120.7 mm, 129 parts (0 on the bottom side), 132 nets.
