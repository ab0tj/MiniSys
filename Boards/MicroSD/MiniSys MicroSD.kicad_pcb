# Repository ab0tj/MiniSys

## KiCad design Boards/MicroSD/MiniSys MicroSD.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C14, C15, C16: .1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C12, C13: 33uF; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C17, C18: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: ACT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: CheapBusTX24-RA; JAE_TX24-120R-LT-H1E; Mouser Part Number 656-TX24120RLTH1E
J2: PORT; PinHeader_2x07_P2.54mm_Vertical
J3: CF0; microSD_HC_Hirose_DM3AT-SF-PEJM5
J4: CF1; microSD_HC_Hirose_DM3AT-SF-PEJM5
J5: LED; PinHeader_1x02_P2.54mm_Horizontal
J6: MISO_SR; PinHeader_2x08_P2.54mm_Vertical
J7: CTRL; PinHeader_2x08_P2.54mm_Vertical
R1, R2, R3, R4, R5: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R7: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8, R9: 4.7k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: 74LS32; SOIC-14_3.9x8.7mm_P1.27mm
U2, U6: 74LS165; SOIC-16_3.9x9.9mm_P1.27mm
U3: 74LS138; SOIC-16_3.9x9.9mm_P1.27mm
U4: 74LS164; SOIC-14_3.9x8.7mm_P1.27mm
U5: 74LS244; SOIC-20W_7.5x12.8mm_P1.27mm
U7, U11: GAL16V8; PLCC-20_THT-Socket
U8: 74LVC125; SOIC-14_3.9x8.7mm_P1.27mm
U9: 74LS393; SOIC-14_3.9x8.7mm_P1.27mm
U10: 74LS123; SOIC-16_3.9x9.9mm_P1.27mm
X1: 20MHz; Oscillator_DIP-8

Connections:
+3V3: C13.1, C14.1, C15.1, C16.1, J1.57 (3V3), J1.64 (3V3), J3.4 (VDD), J4.4 (VDD), R1.2, U8.14 (VCC)
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, J1.58 (5V), J1.59 (5V), J1.60 (5V), J1.61 (5V), J1.62 (5V), R2.2, R3.2, R4.2, R5.2, R6.1, R7.1, R8.2, R9.2, U1.14 (VCC), U2.10 (DS), U2.16 (VCC), U3.16 (VCC), U4.1 (DSA), U4.9 (~MR), U4.14 (VCC), U5.20 (VCC), U6.10 (DS), U6.16 (VCC), U7.20 (VCC), U9.14 (VCC), U10.3 (Clr), U10.11 (Clr), U10.16 (VCC), U11.20 (VCC), X1.8 (Vcc)
/A0: J1.29 (A0), U7.1 (I1/CLK)
/A1: J1.28 (A1), U7.2 (I2)
/A2: J1.27 (A2), U7.3 (I3)
/A3: J1.26 (A3), U7.4 (I4)
/A4: J1.25 (A4), U7.5 (I5)
/A5: J1.24 (A5), U3.1 (A0)
/A6: J1.23 (A6), U3.2 (A1)
/A7: J1.22 (A7), U3.5 (E2)
/A8: J1.21 (A8), J2.1
/A9: J1.20 (A9), U3.3 (A2)
/A10: J1.19 (A10), U1.1
/A11: J1.18 (A11), U1.2
/A12: J1.17 (A12), U1.4
/A13: J1.16 (A13), U1.5
/A14: J1.15 (A14), U1.9
/A15: J1.14 (A15), U1.10
/AEN: J1.90 (AEN), U7.9 (I9)
/CKDIV: U11.17 (I03)
/CLK: J7.6, U4.8 (CP), U8.5, U11.19 (IO1)
/CRD: U7.16 (IO4), U11.2 (I2)
/CWR: U7.17 (I03), U11.1 (I1/CLK)
/D0: J1.81 (D0), U5.18 (O0a), U6.11 (D0), U11.12 (IO8)
/D1: J1.80 (D1), U5.16 (O1a), U6.12 (D1), U11.13 (IO7)
/D2: J1.79 (D2), U5.14 (O2a), U6.13 (D2), U11.14 (IO6)
/D3: J1.78 (D3), U5.12 (O3a), U6.14 (D3)
/D4: J1.77 (D4), U5.9 (O0b), U6.3 (D4)
/D5: J1.76 (D5), U5.7 (O1b), U6.4 (D5)
/D6: J1.75 (D6), U5.5 (O2b), U6.5 (D6)
/D7: J1.74 (D7), U5.3 (O3b), U6.6 (D7)
/MISO: J3.7 (DAT0), J4.7 (DAT0), J7.2, R1.1, U4.2 (DSB)
/MOSI: J7.4, U6.9 (Q7), U8.2
/RDY: J7.12, U2.9 (Q7), U11.4 (I4)
/S0: J6.2, U4.3 (Q0), U5.2 (I0a)
/S1: J6.4, U4.4 (Q1), U5.4 (I1a)
/S2: J6.6, U4.5 (Q2), U5.6 (I2a)
/S3: J6.8, U4.6 (Q3), U5.8 (I3a)
/S4: J6.10, U4.10 (Q4), U5.11 (I0b)
/S5: J6.12, U4.11 (Q5), U5.13 (I1b)
/S6: J6.14, U4.12 (Q6), U5.15 (I2b)
/S7: J6.16, U4.13 (Q7), U5.17 (I3b)
/~CD0: J3.9 (DET_B), R4.1, U11.5 (I5)
/~CD1: J4.9 (DET_B), R5.1, U11.6 (I6)
/~CLK: U2.2 (CP), U6.2 (CP), U11.18 (IO2)
/~CS0: J7.8, U8.9, U11.15 (IO5)
/~CS1: J7.10, U8.12, U11.16 (IO4)
/~DRD: J7.16, U5.1 (OEa), U5.19 (OEb), U7.18 (IO2)
/~DWR: J7.14, U2.1 (~PL), U6.1 (~PL), U7.19 (IO1), U11.9 (I9)
/~IOR: J1.30 (IOR), U7.7 (I7)
/~IOW: J1.31 (IOW), U7.8 (I8)
/~RDY: U2.7 (~Q7), U10.2 (B), U10.10 (B)
/~RST: J1.115 (RESET), U7.13 (IO7), U11.3 (I3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J1.1 (GND), J1.2 (GND), J1.3 (GND), J1.4 (GND), J1.5 (GND), J1.116 (GND), J1.117 (GND), J1.118 (GND), J1.119 (GND), J1.120 (GND), J2.3, J3.6 (VSS), J3.10 (DET_A), J3.11 (SHIELD), J4.6 (VSS), J4.10 (DET_A), J4.11 (SHIELD), J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, J6.13, J6.15, J7.1, J7.3, J7.5, J7.7, J7.9, J7.11, J7.13, J7.15, U1.7 (GND), U2.3 (D4), U2.4 (D5), U2.5 (D6), U2.6 (D7), U2.8 (GND), U2.11 (D0), U2.12 (D1), U2.13 (D2), U2.14 (D3), U2.15 (~CE), U3.8 (GND), U4.7 (GND), U5.10 (GND), U6.8 (GND), U6.15 (~CE), U7.10 (GND), U8.1, U8.4, U8.7 (GND), U8.10, U8.13, U9.2 (MR), U9.7 (GND), U9.12 (MR), U10.1 (A), U10.8 (GND), U10.9 (A), U11.10 (GND), U11.11 (I10/~OE~), X1.4 (GND)
unnamed: C17.1, R8.1, U10.15 (RCext)
unnamed: C17.2, U10.14 (Cext)
unnamed: C18.1, R9.1, U10.7 (RCext)
unnamed: C18.2, U10.6 (Cext)
unnamed: D1.1 (K), U10.4 (~Q)
unnamed: D1.2 (A), R7.2
unnamed: J2.2, R2.1, U3.6 (E3)
unnamed: J2.4, R3.1, U7.14 (IO6)
unnamed: J2.5, U3.14 (O1)
unnamed: J2.7, U3.13 (O2)
unnamed: J2.9, U3.12 (O3)
unnamed: J2.6, J2.8, J2.10, J2.12, J2.14, U7.6 (I6)
unnamed: J2.11, U3.11 (O4)
unnamed: J2.13, U3.10 (O5)
unnamed: J3.2 (DAT3/CD), U8.8
unnamed: J3.3 (CMD), J4.3 (CMD), U8.3
unnamed: J3.5 (CLK), J4.5 (CLK), U8.6
unnamed: J4.2 (DAT3/CD), U8.11
unnamed: J5.1, R6.2
unnamed: J5.2, U10.12 (~Q)
unnamed: U1.8, U7.11 (I10/~OE~)
unnamed: U1.11, U3.4 (E1)
unnamed: U1.3, U1.12
unnamed: U1.6, U1.13
unnamed: U9.6 (Q3), U9.13 (CP)
unnamed: U9.10 (Q1), U11.7 (I7)
unnamed: U9.1 (CP), U11.8 (I8), X1.5 (OUT)

Notes on the sheet:
312.5 kHz
20 MHz
1-2 Closed: 16 bit IO address space 1-2 Open: 8 bit IO address space 3-4 Closed: Add 10H to address 5-6: 020/120H 7-8: 040/140H 9-10: 060/160H 11-12: 300H 13-14: 320H

Board: 2 copper layers, 100.0 x 100.0 mm, 47 parts (0 on the bottom side), 80 nets.

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
