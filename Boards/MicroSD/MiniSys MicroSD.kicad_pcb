# Repository ab0tj/MiniSys (continued)

## KiCad design Boards/PPR Board/PPR Board.kicad_pcb (continued)

Board: 2 copper layers, 100.0 x 100.0 mm, 37 parts (0 on the bottom side), 102 nets.

## KiCad design Boards/8085 CPU/8085 CPU.kicad_pcb

Parts:
C1: 20pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2: 33uF; CP_Radial_D6.3mm_P2.50mm
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14: .1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
J1: CheapBusTX24-RA; JAE_TX24-120R-LT-H1E; Mouser Part Number 656-TX24120RLTH1E
J2: JTAG; Pin_Header_Straight_2x05_Pitch2.54mm
R1, R2, R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: 74HCT04; DIP-14_W7.62mm
U2: 74HCT08; DIP-14_W7.62mm
U3: 74HCT245; DIP-20_W7.62mm
U4: 8085; DIP-40_W15.24mm
U5: 74HCT257; DIP-16_W7.62mm
U7: 74HCT573; DIP-20_W7.62mm
U8: ATF1508AS_(84_PLCC); PLCC84
U9, U10: 6116; DIP-24_W7.62mm
Y1: 6MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, J1.58 (5V), J1.59 (5V), J1.60 (5V), J1.61 (5V), J1.62 (5V), J2.4, R1.1, R2.1, R3.1, U1.14 (VCC), U2.14 (VCC), U3.20 (VCC), U4.40 (VCC), U5.16 (VCC), U7.20 (VCC), U8.3 (VCCINT), U8.13 (VCCIO), U8.26 (VCCIO), U8.38 (VCCIO), U8.43 (VCCINT), U8.53 (VCCIO), U8.66 (VCCIO), U8.78 (VCCIO), U9.24 (VCC), U10.24 (VCC)
/A8: U4.21 (A8), U5.2 (I0a)
/A9: U4.22 (A9), U5.5 (I0b)
/A10: U4.23 (A10), U5.14 (I0c)
/A11: U4.24 (A11), U5.11 (I0d)
/A12: U4.25 (A12), U8.79 (P56)
/A13: U4.26 (A13), U8.77 (P55)
/A14: U4.27 (A14), U8.75 (P53)
/A15: U4.28 (A15), U8.74 (P52)
/AD0: U3.2 (A0), U4.12 (AD0), U7.2 (D0), U8.73 (P52)
/AD1: U3.3 (A1), U4.13 (AD1), U7.3 (D1), U8.70 (P50)
/AD2: U3.4 (A2), U4.14 (AD2), U7.4 (D2), U8.56 (P39)
/AD3: U3.5 (A3), U4.15 (AD3), U7.5 (D3), U8.63 (P44)
/AD4: U3.6 (A4), U4.16 (AD4), U7.6 (D4), U8.57 (P40)
/AD5: U3.7 (A5), U4.17 (AD5), U7.7 (D5), U8.65 (P46)
/AD6: U3.8 (A6), U4.18 (AD6), U7.8 (D6), U8.67 (P47)
/AD7: U3.9 (A7), U4.19 (AD7), U7.9 (D7), U8.64 (P45)
/ALE: U4.30 (ALE), U7.11 (Load), U8.83 (I/O/GCK1)
/CLK1: J1.38 (CLK1), U2.6
/D0: J1.81 (D0), U3.18 (B0)
/D1: J1.80 (D1), U3.17 (B1)
/D2: J1.79 (D2), U3.16 (B2)
/D3: J1.78 (D3), U3.15 (B3)
/D4: J1.77 (D4), U3.14 (B4)
/D5: J1.76 (D5), U3.13 (B5)
/D6: J1.75 (D6), U3.12 (B6)
/D7: J1.74 (D7), U3.11 (B7)
/HLDA: U1.9, U3.19 (CE), U4.38 (HLDA), U5.15 (E), U7.1 (OE), U8.84 (INPUT/OE1)
/IO~M: U4.34 (IO/~M), U5.1 (S), U8.54 (P37)
/MA0: U8.20 (P12), U9.8 (A0), U10.8 (A0)
/MA1: U8.22 (P14), U9.7 (A1), U10.7 (A1)
/MA2: U8.24 (P15), U9.6 (A2), U10.6 (A2)
/MA3: U8.25 (P16), U9.5 (A3), U10.5 (A3)
/MA4: U8.11 (P7), U9.4 (A4), U10.4 (A4)
/MA5: U8.10 (P6), U9.3 (A5), U10.3 (A5)
/MA6: U8.12 (PD1), U9.2 (A6), U10.2 (A6)
/MD0: U8.44 (P30), U10.9 (D0)
/MD1: U8.45 (PD2), U10.10 (D1)
/MD2: U8.46 (P31), U10.11 (D2)
/MD3: U8.48 (P32), U10.13 (D3)
/MD4: U8.49 (P33), U10.14 (D4)
/MD5: U8.50 (P34), U10.15 (D5)
/MD6: U8.51 (P35), U10.16 (D6)
/MD7: U8.52 (P36), U10.17 (D7)
/MD8: U8.5 (P2), U9.9 (D0)
/MD9: U8.4 (P1), U9.10 (D1)
/MD10: U8.6 (P3), U9.11 (D2)
/MD11: U8.9 (P5), U9.13 (D3)
/MD12: U8.8 (P4), U9.14 (D4)
/RDY: U4.35 (READY), U8.40 (P28)
/RST: U4.3 (RESET_OUT), U8.1 (INPUT/GCLR)
/S0: U4.29 (S0), U8.68 (P48)
/S1: U4.33 (S1), U8.69 (P49)
/bA0: J1.29 (A0), U7.19 (Q0)
/bA1: J1.28 (A1), U7.18 (Q1)
/bA2: J1.27 (A2), U7.17 (Q2)
/bA3: J1.26 (A3), U7.16 (Q3)
/bA4: J1.25 (A4), U7.15 (Q4)
/bA5: J1.24 (A5), U7.14 (Q5)
/bA6: J1.23 (A6), U7.13 (Q6)
/bA7: J1.22 (A7), U7.12 (Q7)
/bA8: J1.21 (A8), U5.4 (Za)
/bA9: J1.20 (A9), U5.7 (Zb)
/bA10: J1.19 (A10), U5.12 (Zc)
/bA11: J1.18 (A11), U5.9 (Zd)
/bA12: J1.17 (A12), U8.18 (P11)
/bA13: J1.16 (A13), U8.17 (P10)
/bA14: J1.15 (A14), U8.21 (P13)
/bA15: J1.14 (A15), U8.16 (P9)
/bA16: J1.13 (A16), U8.35 (P24)
/bA17: J1.12 (A17), U8.33 (P22)
/bA18: J1.11 (A18), U8.36 (P25)
/bA19: J1.10 (A19), U8.31 (P21)
/bA20: J1.9 (A20), U8.29 (P19)
/bA21: J1.8 (A21), U8.34 (P23)
/bA22: J1.7 (A22), U8.28 (P18)
/bA23: J1.6 (A23), U8.27 (P17)
/~HLDA: J1.83 (HLDA), U1.8
/~HOLD: J1.82 (HOLD), U1.1
/~INT: J1.100 (INT), U1.3
/~INTA: U2.2, U2.9, U2.10, U4.11 (~INTA), U8.2 (I/O/GCK2)
/~IOR: J1.30 (IOR), U8.60 (P42)
/~IOW: J1.31 (IOW), U8.61 (P43)
/~IOWT: J1.86 (IOWT), U8.80 (P57)
/~M1: J1.84 (M1), U8.30 (P20)
/~MEMR: J1.32 (MEMR), U8.41 (P29)
/~MEMW: J1.33 (MEMW), U8.15 (P8)
/~MOE: U8.58 (P41), U9.20 (OE), U10.20 (OE)
/~MWE: U8.39 (P27), U9.21 (WE), U10.21 (WE)
/~MWT: J1.87 (MWT), U8.81 (I/O/GCK3)
/~NMI: J1.99 (NMI), U1.5
/~RD: U2.1, U4.32 (~RD), U8.76 (P54)
/~RFSH: J1.85 (RFSH), U8.37 (P26)
/~RST: J1.115 (RESET), U4.36 (~RESET_IN)
/~WR: U4.31 (~WR), U8.55 (P38)
/~bINTA: J1.101 (INTA), U2.8
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.1 (GND), J1.2 (GND), J1.3 (GND), J1.4 (GND), J1.5 (GND), J1.116 (GND), J1.117 (GND), J1.118 (GND), J1.119 (GND), J1.120 (GND), J1.121, J1.122, J2.2, J2.10, U1.7 (GND), U1.11, U1.13, U2.7 (GND), U2.12, U2.13, U3.10 (GND), U4.5 (SID), U4.7 (RST7_5), U4.8 (RST6_5), U4.9 (RST5_5), U4.20 (GND), U5.3 (I1a), U5.6 (I1b), U5.8 (GND), U5.10 (I1d), U5.13 (I1c), U7.10 (GND), U8.7 (GND), U8.19 (GND), U8.32 (GND), U8.42 (GND), U8.47 (GND), U8.59 (GND), U8.72 (GND), U8.82 (GND), U9.1 (A7), U9.12 (GND), U9.18 (CS), U9.19 (A10), U9.22 (A9), U9.23 (A8), U10.1 (A7), U10.12 (GND), U10.18 (CS), U10.19 (A10), U10.22 (A9), U10.23 (A8)
unnamed: C1.1, U4.2 (X2), Y1.1
unnamed: J2.1, U8.62 (TCK)
unnamed: J2.3, U8.71 (TDO)
unnamed: J2.5, U8.23 (TMS)
unnamed: J2.9, U8.14 (TDI)
unnamed: R1.2, U9.17 (D7)
unnamed: R2.2, U9.16 (D6)
unnamed: R3.2, U9.15 (D5)
unnamed: U1.2, U4.39 (HOLD)
unnamed: U1.4, U4.10 (INTR)
unnamed: U1.6, U4.6 (TRAP)
unnamed: U2.3, U3.1 (A->B)
unnamed: U2.4, U2.5, U4.37 (CLK_OUT)
unnamed: U4.1 (X1), Y1.2

Notes on the sheet:
C1 not required if Y1 > 4MHz
MMU Page Registers

Board: 2 copper layers, 100.0 x 100.0 mm, 29 parts (0 on the bottom side), 111 nets.

## KiCad design Boards/Breakout/MiniSys-Breakout.kicad_pcb

Parts:
C1, C2: .1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: HI; LED_D5.0mm
D2: LO; LED_D5.0mm
D3: OSC; LED_D5.0mm
D4: 3V3; LED_D5.0mm
D5: +12V; LED_D5.0mm
D6: 5V; LED_D5.0mm
D7: -12V; LED_D5.0mm
D8: +5VSB; LED_D5.0mm
J1: CheapBusTX24-ST; JAE_TX24-120R-6ST-H1E; Mouser Part Number 656-TX24120RLTH1E
J2: GND; Pin_Header_Straight_1x01_Pitch2.54mm
J3: X-ADDR; Pin_Header_Straight_2x08_Pitch2.54mm
J4, J24: CTRL; Pin_Header_Straight_2x08_Pitch2.54mm
J5: CLK1; Pin_Header_Straight_1x02_Pitch2.54mm
J6: SPR; Pin_Header_Straight_2x03_Pitch2.54mm
J7: LOGIC; Pin_Header_Straight_1x01_Pitch2.54mm
J8: +12V; Pin_Header_Straight_1x01_Pitch2.54mm
J9: +3.3V; Pin_Header_Straight_1x01_Pitch2.54mm
J10: -12V; Pin_Header_Straight_1x01_Pitch2.54mm
J11: H-ADDR; Pin_Header_Straight_2x08_Pitch2.54mm
J12: DMA; Pin_Header_Straight_2x08_Pitch2.54mm
J13: CLK2; Pin_Header_Straight_1x02_Pitch2.54mm
J14: +5V; Pin_Header_Straight_1x01_Pitch2.54mm
J15: VBAT; Pin_Header_Straight_1x01_Pitch2.54mm
J16: L-ADDR; Pin_Header_Straight_2x08_Pitch2.54mm
J17, J20: INT; Pin_Header_Straight_2x08_Pitch2.54mm
J18: CLK3; Pin_Header_Straight_1x02_Pitch2.54mm
J19: H-DATA; Pin_Header_Straight_2x08_Pitch2.54mm
J21: CLK4; Pin_Header_Straight_1x02_Pitch2.54mm
J22: L-DATA; Pin_Header_Straight_2x08_Pitch2.54mm
J23: MISC; Pin_Header_Straight_2x08_Pitch2.54mm
J25: SPARE; Pin_Header_Straight_2x08_Pitch2.54mm
J26: +5VSB; Pin_Header_Straight_1x01_Pitch2.54mm
R1: 2.2M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R5: 1000; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 4.7M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R9: 1500; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R10: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: 4001; DIP-14_W7.62mm

Connections:
+3V3: J1.57, J1.64, J9.1, R6.2
+5V: C2.1, D3.2 (A), J1.58, J1.59, J1.60, J1.61, J1.62, J14.1, R2.2, R4.2, R8.2, U1.14 (VDD)
+12V: J1.65, J8.1, R7.2
-12V: J1.56, J10.1, R9.2
/+5VSB: J1.63, J26.1, R10.2
/A0: J1.29, J16.15
/A1: J1.28, J16.13
/A2: J1.27, J16.11
/A3: J1.26, J16.9
/A4: J1.25, J16.7
/A5: J1.24, J16.5
/A6: J1.23, J16.3
/A7: J1.22, J16.1
/A8: J1.21, J11.15
/A9: J1.20, J11.13
/A10: J1.19, J11.11
/A11: J1.18, J11.9
/A12: J1.17, J11.7
/A13: J1.16, J11.5
/A14: J1.15, J11.3
/A15: J1.14, J11.1
/A16: J1.13, J3.15
/A17: J1.12, J3.13
/A18: J1.11, J3.11
/A19: J1.10, J3.9
/A20: J1.9, J3.7
/A21: J1.8, J3.5
/A22: J1.7, J3.3
/A23: J1.6, J3.1
/CLK1: J1.38, J5.1
/CLK2: J1.39, J13.1
/CLK3: J1.40, J18.1
/CLK4: J1.41, J21.1
/D0: J1.81, J22.15
/D1: J1.80, J22.13
/D2: J1.79, J22.11
/D3: J1.78, J22.9
/D4: J1.77, J22.7
/D5: J1.76, J22.5
/D6: J1.75, J22.3
/D7: J1.74, J22.1
/D8: J1.73, J19.15
/D9: J1.72, J19.13
/D10: J1.71, J19.11
/D11: J1.70, J19.9
/D12: J1.69, J19.7
/D13: J1.68, J19.5
/D14: J1.67, J19.3
/D15: J1.66, J19.1
/SCL: J1.114, J23.11
/SDA: J1.113, J23.9
/SPR1: J1.49, J25.1
/SPR2: J1.50, J25.3
/SPR3: J1.51, J25.5
/SPR4: J1.52, J6.1
/SPR5: J1.53, J6.3
/SPR6: J1.54, J6.5
/SPR7: J1.110, J25.13
/SPR8: J1.111, J25.15
/SPR9: J1.112, J23.1
/VBAT: J1.55, J15.1
/~AEN: J1.90, J23.3
/~BHE: J1.37, J24.15
/~DACK0: J1.92, J12.15
/~DACK1: J1.94, J12.11
/~DACK2: J1.96, J12.7
/~DACK3: J1.98, J12.3
/~DRQ0: J1.91, J12.13
/~DRQ1: J1.93, J12.9
/~DRQ2: J1.95, J12.5
/~DRQ3: J1.97, J12.1
/~EOP: J1.88, J4.13
/~HLDA: J1.83, J4.3
/~HOLD: J1.82, J4.1
/~INT: J1.100, J17.1
/~INTA: J1.101, J23.7
/~IO16: J1.35, J24.11
/~IOR: J1.30, J24.1
/~IOW: J1.31, J24.3
/~IOWT: J1.86, J4.9
/~IRQ0: J1.109, J20.15
/~IRQ1: J1.108, J20.13
/~IRQ2: J1.107, J20.11
/~IRQ3: J1.106, J20.9
/~IRQ4: J1.105, J20.7
/~IRQ5: J1.104, J20.5
/~IRQ6: J1.103, J20.3
/~IRQ7: J1.102, J20.1
/~IRQ8: J1.48, J17.15
/~IRQ9: J1.47, J17.13
/~IRQ10: J1.46, J17.11
/~IRQ11: J1.45, J17.9
/~IRQ12: J1.44, J17.7
/~IRQ13: J1.43, J17.5
/~IRQ14: J1.42, J17.3
/~M1: J1.84, J4.5
/~M16: J1.36, J24.13
/~MASTER: J1.89, J4.15
/~MEMR: J1.32, J24.5
/~MEMW: J1.33, J24.7
/~MOVL: J1.34, J24.9
/~MWT: J1.87, J4.11
/~NMI: J1.99, J23.5
/~RESET: J1.115, J23.13
/~RFSH: J1.85, J4.7
GND: C2.2, D4.1 (K), D5.1 (K), D6.1 (K), D7.2 (A), D8.1 (K), J1.1, J1.2, J1.3, J1.4, J1.5, J1.116, J1.117, J1.118, J1.119, J1.120, J2.1, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J4.2, J4.4, J4.6, J4.8, J4.10, J4.12, J4.14, J4.16, J5.2, J11.2, J11.4, J11.6, J11.8, J11.10, J11.12, J11.14, J11.16, J12.2, J12.4, J12.6, J12.8, J12.10, J12.12, J12.14, J12.16, J13.2, J16.2, J16.4, J16.6, J16.8, J16.10, J16.12, J16.14, J16.16, J17.2, J17.4, J17.6, J17.8, J17.10, J17.12, J17.14, J17.16, J18.2, J19.2, J19.4, J19.6, J19.8, J19.10, J19.12, J19.14, J19.16, J20.2, J20.4, J20.6, J20.8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
unnamed: C1.1, R4.1, U1.8, U1.9
unnamed: C1.2, U1.4
unnamed: D1.1 (K), D2.2 (A), R1.1, U1.3, U1.5
unnamed: D1.2 (A), D2.1 (K), R2.1, R3.2
unnamed: D3.1 (K), R5.2
unnamed: D4.2 (A), R6.1
unnamed: D5.2 (A), R7.1
unnamed: D6.2 (A), R8.1
unnamed: D7.1 (K), R9.1
unnamed: D8.2 (A), R10.1
unnamed: J7.1, R1.2, U1.1, U1.2
unnamed: J6.2, J25.7
unnamed: J6.4, J25.9
unnamed: J6.6, J25.11
unnamed: R5.1, U1.11
unnamed: U1.6, U1.10, U1.12, U1.13

Notes on the sheet:
Built in logic probe

Board: 2 copper layers, 100.0 x 100.0 mm, 47 parts (1 on the bottom side), 122 nets.

## Code that names these connections

File Software/Backplane/Controller/ports.h:

#define SIG_SDA		PA0
#define SIG_PSON	PA1
#define SIG_SCL		PA2
#define SIG_PWROK	PA3
#define MON_3V3		PA4
#define MON_5V		PA5
#define MON_12V		PA6
#define MON_BAT		PA7
#define BTN_DEBUG	PB0
#define BTN_RESET	PB1
#define SIG_TEMP	PB3
#define SIG_NMI		PB4
#define SIG_RESET	PB5
#define BTN_POWER	PB6
#define PIN_USI		PINA
#define DDR_USI		DDRA
#define PORT_USI	PORTA

## Commit log

2019-11-13 Tweak Pi read cycle time to eliminate (infrequent) errors
2020-03-27 C++ version of the PiBoard software now working
2020-03-27 Added more files to git
2020-07-19 Add MicroSD CUPL files. Still untested.
2020-08-24 Add CON_SI signal support
