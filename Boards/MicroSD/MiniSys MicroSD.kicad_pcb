# Repository ab0tj/MiniSys (continued)

## KiCad design Boards/80186EB CPU/Minisys 186 CPU.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C19, C20: .1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C21: 33uF; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: CheapBusTX24-RA; TX24-120R-LT-H1E; Mouser Part Number 656-TX24120RLTH1E
J2: CLK OUT; PinHeader_2x02_P2.54mm_Vertical
J3: Serial; PinHeader_1x05_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R7, R8, R19: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9, R10, R11, R12, R13, R14, R15, R16, R17, R18: 2k2; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: 80C186EB; PLCC-84_THT-Socket
U2, U3, U4: 74HCT245; SO-20_12.8x7.5mm_P1.27mm
U8, U9: GAL16V8; PLCC-20_THT-Socket
U10, U11, U12: 74HC670; SOIC-16_3.9x9.9mm_P1.27mm
U13, U14, U15: 74HCT573; SO-20_12.8x7.5mm_P1.27mm
U16: 74HC75; SOIC-16_3.9x9.9mm_P1.27mm
X1: CPU CLK; Oscillator_DIP-8

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C19.1, C20.1, C21.1, J1.58 (5V), J1.59 (5V), J1.60 (5V), J1.61 (5V), J1.62 (5V), J3.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.1, U1.1 (VCC), U1.3 (~ERROR), U1.23 (VCC), U1.42 (VCC), U1.46 (T0IN), U1.48 (T1IN), U1.64 (VCC), U2.20 (VCC), U3.20 (VCC), U4.20 (VCC), U8.20 (VCC), U9.20 (VCC), U10.16 (VCC), U11.16 (VCC), U12.16 (VCC), U13.20 (VCC), U14.20 (VCC), U15.20 (VCC), U16.5 (VCC), X1.8 (Vcc)
/A0: J1.29 (A0), U13.19 (Q0)
/A1: J1.28 (A1), U10.14 (Wa), U11.14 (Wa), U12.14 (Wa), U13.18 (Q1)
/A2: J1.27 (A2), U10.13 (Wb), U11.13 (Wb), U12.13 (Wb), U13.17 (Q2)
/A3: J1.26 (A3), U13.16 (Q3)
/A4: J1.25 (A4), U13.15 (Q4)
/A5: J1.24 (A5), U13.14 (Q5)
/A6: J1.23 (A6), U13.13 (Q6)
/A7: J1.22 (A7), U13.12 (Q7)
/A8: J1.21 (A8), U14.19 (Q0)
/A9: J1.20 (A9), U14.18 (Q1)
/A10: J1.19 (A10), U14.17 (Q2)
/A11: J1.18 (A11), U14.16 (Q3)
/A12: J1.17 (A12), U14.15 (Q4)
/A13: J1.16 (A13), U14.14 (Q5)
/A14: J1.15 (A14), U14.13 (Q6)
/A15: J1.14 (A15), U14.12 (Q7)
/A16: J1.13 (A16), U15.19 (Q0)
/A17: J1.12 (A17), U15.18 (Q1)
/A18: J1.11 (A18), U15.17 (Q2)
/A19: J1.10 (A19), U15.16 (Q3)
/A20: J1.9 (A20), U15.15 (Q4)
/A21: J1.8 (A21), U15.14 (Q5)
/A22: J1.7 (A22), U15.13 (Q6)
/A23: J1.6 (A23), U15.12 (Q7)
/AD0: U1.61 (AD0), U2.2 (A0), U10.15 (D1), U13.2 (D0), U16.7 (D3)
/AD1: U1.66 (AD1), U2.3 (A1), U10.1 (D2), U13.3 (D1)
/AD2: U1.68 (AD2), U2.4 (A2), U10.2 (D3), U13.4 (D2)
/AD3: U1.70 (AD3), U2.5 (A3), U10.3 (D4), U13.5 (D3)
/AD4: U1.72 (AD4), U2.6 (A4), U11.15 (D1), U13.6 (D4)
/AD5: U1.74 (AD5), U2.7 (A5), U11.1 (D2), U13.7 (D5)
/AD6: U1.76 (AD6), U2.8 (A6), U11.2 (D3), U13.8 (D6)
/AD7: U1.78 (AD7), U2.9 (A7), U11.3 (D4), U13.9 (D7)
/AD8: U1.62 (AD8), U3.2 (A0), U4.2 (A0), U12.15 (D1), U14.2 (D0)
/AD9: U1.67 (AD9), U3.3 (A1), U4.3 (A1), U12.1 (D2), U14.3 (D1)
/AD10: U1.69 (AD10), U3.4 (A2), U4.4 (A2), U14.4 (D2)
/AD11: U1.71 (AD11), U3.5 (A3), U4.5 (A3), U14.5 (D3)
/AD12: U1.73 (AD12), U3.6 (A4), U4.6 (A4), U14.6 (D4)
/AD13: U1.75 (AD13), U3.7 (A5), U4.7 (A5), U14.7 (D5)
/AD14: R9.2, U1.77 (AD14), U3.8 (A6), U4.8 (A6), U10.5 (Ra), U11.5 (Ra), U12.5 (Ra)
/AD15: R10.2, U1.79 (AD15), U3.9 (A7), U4.9 (A7), U10.4 (Rb), U11.4 (Rb), U12.4 (Rb)
/ALE: U1.6 (ALE), U13.11 (Load), U14.11 (Load), U15.11 (Load), U16.4 (E23), U16.13 (E01)
/CLK1: J1.38 (CLK1), U1.44 (CLKOUT)
/CLK2: J1.39 (CLK2), J2.2
/CLK3: J1.40 (CLK3), J2.4
/D0: J1.81 (D0), U2.18 (B0), U4.18 (B0)
/D1: J1.80 (D1), U2.17 (B1), U4.17 (B1)
/D2: J1.79 (D2), U2.16 (B2), U4.16 (B2)
/D3: J1.78 (D3), U2.15 (B3), U4.15 (B3)
/D4: J1.77 (D4), U2.14 (B4), U4.14 (B4)
/D5: J1.76 (D5), U2.13 (B5), U4.13 (B5)
/D6: J1.75 (D6), U2.12 (B6), U4.12 (B6)
/D7: J1.74 (D7), U2.11 (B7), U4.11 (B7)
/D8: J1.73 (D8), U3.18 (B0)
/D9: J1.72 (D9), U3.17 (B1)
/D10: J1.71 (D10), U3.16 (B2)
/D11: J1.70 (D11), U3.15 (B3)
/D12: J1.69 (D12), U3.14 (B4)
/D13: J1.68 (D13), U3.13 (B5)
/D14: J1.67 (D14), U3.12 (B6)
/D15: J1.66 (D15), U3.11 (B7)
/DT~R: U1.16 (DT/~R), U2.1 (A->B), U3.1 (A->B), U4.1 (A->B), U8.9 (I9)
/HLDA: U1.12 (HLDA), U8.11 (I10/~OE~), U13.1 (OE), U14.1 (OE), U15.1 (OE)
/HOLD: U1.13 (HOLD), U9.14 (IO6)
/INT: U1.31 (INT0), U9.16 (IO4)
/IO: U8.12 (IO8), U9.11 (I10/~OE~)
/NMI: U1.17 (NMI), U9.15 (IO5)
/READY: U1.18 (READY), U9.13 (IO7)
/iA0: U9.4 (I4), U16.9 (Q3)
/mA14: R9.1, U10.10 (Q1), U14.8 (D6)
/mA15: R10.1, U10.9 (Q2), U14.9 (D7)
/mA16: R11.1, U10.7 (Q3), U15.2 (D0)
/mA17: R12.1, U10.6 (Q4), U15.3 (D1)
/mA18: R13.1, U11.10 (Q1), U15.4 (D2)
/mA19: R14.1, U11.9 (Q2), U15.5 (D3)
/mA20: R15.1, U11.7 (Q3), U15.6 (D4)
/mA21: R16.1, U11.6 (Q4), U15.7 (D5)
/mA22: R17.1, U12.10 (Q1), U15.8 (D6)
/mA23: R18.1, U12.9 (Q2), U15.9 (D7)
/pA16: R11.2, U1.80 (A16)
/pA17: R12.2, U1.81 (A17)
/pA18: R13.2, U1.82 (A18)
/pA19: R14.2, U1.83 (A19/~ONCE)
/~BHE: J1.37 (BHE), U1.7 (~BHE/RFSH), U9.5 (I5)
/~BKPRT: U1.26 (P1.2/~GCS2), U8.2 (I2)
/~BKWR: U8.15 (IO5), U10.12 (~Ew), U11.12 (~Ew), U12.12 (~Ew)
/~DEN: U1.11 (~DEN), U8.8 (I8), U9.6 (I6)
/~HCE: U3.19 (CE), U9.18 (IO2)
/~HLDA: J1.83 (HLDA), U8.13 (IO7)
/~HOLD: J1.82 (HOLD), U9.9 (I9)
/~INT: J1.100 (INT), U9.7 (I7)
/~INTA: J1.101 (INTA), U1.33 (INT2/~INTA0)
/~IO16: J1.35 (IO16), U9.3 (I3)
/~IOR: J1.30 (IOR), U8.19 (IO1)
/~IOW: J1.31 (IOW), U8.18 (IO2)
/~IOWT: J1.86 (IOWT), U9.1 (I1/CLK)
/~LCE: U2.19 (CE), U9.19 (IO1)
/~M1: J1.84 (M1), U8.14 (IO6)
/~MEMR: J1.32 (MEMR), U8.17 (I03)
/~MEMW: J1.33 (MEMW), U8.16 (IO4)
/~MWT: J1.87 (MWT), U9.2 (I2)
/~NMI: J1.99 (NMI), U9.8 (I8)
/~RD: U1.4 (~RD), U8.3 (I3)
/~RST: J1.115 (RESET), U1.37 (~RESIN)
/~S0: U8.5 (I5), U16.16 (Q0)
/~S1: U8.6 (I6), U16.15 (Q1)
/~S2: U8.7 (I7), U16.10 (Q2)
/~WINDOW: U1.27 (P1.1/~GCS1), U10.11 (~Er), U11.11 (~Er), U12.11 (~Er)
/~WP: U1.28 (P1.0/~GCS0), U8.1 (I1/CLK)
/~WR: U1.5 (~WR), U8.4 (I4)
/~XCE: U4.19 (CE), U9.17 (I03)
/~pS0: U1.10 (~S0), U16.2 (D0)
/~pS1: U1.9 (~S1), U16.3 (D1)
/~pS2: U1.8 (~S2), U16.6 (D2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C19.2, C20.2, C21.2, J1.1 (GND), J1.2 (GND), J1.3 (GND), J1.4 (GND), J1.5 (GND), J1.116 (GND), J1.117 (GND), J1.118 (GND), J1.119 (GND), J1.120 (GND), J1.121, J1.122, J3.2, R7.2, R8.2, R15.2, R16.2, R17.2, R18.2, R19.2, U1.2 (GND), U1.14 (~TEST/BUSY), U1.22 (GND), U1.32 (INT1), U1.35 (INT4), U1.39 (PEREQ), U1.43 (GND), U1.63 (GND), U1.65 (GND), U1.84 (GND), U2.10 (GND), U3.10 (GND), U4.10 (GND), U8.10 (GND), U9.10 (GND), U10.8 (GND), U11.8 (GND), U12.2 (D3), U12.3 (D4), U12.8 (GND), U13.10 (GND), U14.10 (GND), U15.10 (GND), U16.12 (GND), X1.1 (EN), X1.4 (GND)
unnamed: D1.1 (K), U1.49 (P2.7)
unnamed: D1.2 (A), R6.2
unnamed: J2.1, U1.45 (T0OUT)
unnamed: J2.3, U1.47 (T1OUT)
unnamed: J3.3, R7.1, U1.51 (~CTS0)
unnamed: J3.4, U1.52 (TXD0)
unnamed: J3.5, R8.1, U1.53 (RXD0)
unnamed: R1.1, U1.57 (P2.0/RXD1)
unnamed: R2.1, U1.59 (P2.2/BCLK1)
unnamed: R3.1, U1.56 (P2.4/~CTS1)
unnamed: R4.1, U1.54 (P2.5/BCLK0)
unnamed: R5.1, U1.50 (P2.6)
unnamed: R19.1, U1.34 (INT3/~INTA1)
unnamed: U1.41 (CLKIN), X1.5 (OUT)

Board: 2 copper layers, 100.0 x 100.0 mm, 56 parts (0 on the bottom side), 129 nets.

## KiCad design Boards/Ethernet/Ethernet.kicad_pcb

Parts:
C1, C7: 33uF; CP_Radial_Tantal_D5.5mm_P2.50mm
C2, C3, C4, C5, C6, C8, C9, C10: .1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1: RX; LED_D3.0mm
D2: TX; LED_D3.0mm
D3: 100; LED_D3.0mm
D4: FDX; LED_D3.0mm
D5: COL; LED_D3.0mm
J1: CheapBusTX24-RA; JAE_TX24-120R-LT-H1E; Mouser Part Number 656-TX24120RLTH1E
J2: WIZ_J1; Pin_Header_Straight_2x14_Pitch2.54mm
J3: WIZ_J2; Pin_Header_Straight_2x14_Pitch2.54mm
J4: INT; Pin_Header_Straight_2x08_Pitch2.54mm
JP1: 8BIT; Pin_Header_Straight_1x02_Pitch2.54mm
JP2: INDR; Pin_Header_Straight_1x02_Pitch2.54mm
R1: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R4, R5, R6: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: LOW ADDR; SW_DIP_x7_W7.62mm_Slide
SW2: HI ADDR; SW_DIP_x6_W7.62mm_Slide
U1, U2, U3, U4: GAL16V8; DIP-20_W7.62mm
U5, U6: 74HCT244; DIP-20_W7.62mm

Connections:
+3V3: C1.1, C2.1, C3.1, J1.57 (3V3), J1.64 (3V3), J2.1, J3.1
+5V: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, J1.58 (5V), J1.59 (5V), J1.60 (5V), J1.61 (5V), J1.62 (5V), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, U1.20 (VCC), U2.20 (VCC), U3.20 (VCC), U4.20 (VCC), U5.20 (VCC), U6.20 (VCC)
/+5VSB: J1.63 (5VSB)
/+12V: J1.65 (12V)
/-12V: J1.56 (-12V)
/A0: J2.28, U3.14 (IO6)
/A1: J2.27, U3.13 (IO7)
/A2: J2.26, U3.12 (IO8)
/A3: U1.18 (IO2), U4.2 (I2), U5.18 (1Y0)
/A4: U1.17 (I03), U4.3 (I3), U5.16 (1Y1)
/A5: U1.14 (IO6), U4.4 (I4), U5.14 (1Y2)
/A6: U1.13 (IO7), U4.5 (I5), U5.12 (1Y3)
/A7: U1.12 (IO8), U4.6 (I6), U5.3 (2Y0)
/A8: U1.11 (I10/~OE~), U4.7 (I7), U5.5 (2Y1)
/A9: U1.9 (I9), U4.8 (I8), U5.7 (2Y2)
/A10: J1.19 (A10), U2.17 (I03)
/A11: J1.18 (A11), U2.14 (IO6)
/A12: J1.17 (A12), U2.13 (IO7)
/A13: J1.16 (A13), U2.12 (IO8)
/A14: J1.15 (A14), U2.11 (I10/~OE~)
/A15: J1.14 (A15), U2.9 (I9)
/ASEL: U3.15 (IO5), U4.1 (I1/CLK)
/BRDY0: J3.14, U6.17 (2A0)
/BRDY1: J3.13, U6.15 (2A1)
/BRDY2: J3.12, U6.13 (2A2)
/BRDY3: J3.11, U6.11 (2A3)
/D0: J1.81 (D0), J2.17, U6.3 (2Y0)
/D1: J1.80 (D1), J2.16, U6.5 (2Y1)
/D2: J1.79 (D2), J2.15, U6.7 (2Y2)
/D3: J1.78 (D3), J2.14, U6.9 (2Y3)
/D4: J1.77 (D4), J2.13
/D5: J1.76 (D5), J2.12
/D6: J1.75 (D6), J2.11
/D7: J1.74 (D7), J2.10
/D8: J1.73 (D8), J2.9
/D9: J1.72 (D9), J2.8
/D10: J1.71 (D10), J2.7
/D11: J1.70 (D11), J2.6
/D12: J1.69 (D12), J2.5
/D13: J1.68 (D13), J2.4
/D14: J1.67 (D14), J2.3
/D15: J1.66 (D15), J2.2
/bA0: J1.29 (A0), U3.7 (I7)
/bA1: J1.28 (A1), U3.6 (I6)
/bA2: J1.27 (A2), U3.5 (I5)
/bA3: J1.26 (A3), U5.2 (1A0)
/bA4: J1.25 (A4), U5.4 (1A1)
/bA5: J1.24 (A5), U5.6 (1A2)
/bA6: J1.23 (A6), U5.8 (1A3)
/bA7: J1.22 (A7), U5.17 (2A0)
/bA8: J1.21 (A8), U5.15 (2A1)
/bA9: J1.20 (A9), U5.13 (2A2)
/eA3: J2.25, U4.19 (IO1)
/eA4: J2.24, U4.18 (IO2)
/eA5: J2.23, U4.17 (I03)
/eA6: J2.22, U4.16 (IO4)
/eA7: J2.21, U4.15 (IO5)
/eA8: J2.20, U4.14 (IO6)
/eA9: J2.19, U4.13 (IO7)
/~8BIT: J3.2, JP1.1, R1.2, U3.4 (I4)
/~ACT: J3.9
/~AEN: J1.90 (AEN), U3.9 (I9)
/~COL: J3.6, U6.8 (1A3)
/~CS: J3.19, U3.19 (IO1)
/~FDX: J3.7, U6.6 (1A2)
/~HI_ADDR: U2.16 (IO4), U3.2 (I2)
/~INT: J3.18, U4.11 (I10/~OE~)
/~IO16: J1.35 (IO16), U3.17 (I03)
/~IOR: J1.30 (IOR), U3.8 (I8)
/~IOW: J1.31 (IOW), J3.21
/~IRQ0: J1.109 (IRQ0), J4.16
/~IRQ1: J1.108 (IRQ1), J4.14
/~IRQ2: J1.107 (IRQ2), J4.12
/~IRQ3: J1.106 (IRQ3), J4.10
/~IRQ4: J1.105 (IRQ4), J4.8
/~IRQ5: J1.104 (IRQ5), J4.6
/~IRQ6: J1.103 (IRQ6), J4.4
/~IRQ7: J1.102 (IRQ7), J4.2
/~LINK: J3.3
/~RD: J3.20, U3.16 (IO4)
/~RESET: J1.115 (RESET), J3.17
/~RX: J3.5, U5.11 (2A3)
/~SPD: J3.8, U6.4 (1A1)
/~STS: U3.18 (IO2), U6.19 (2OE)
/~TX: J3.4, U6.2 (1A0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.1 (GND), J1.2 (GND), J1.3 (GND), J1.4 (GND), J1.5 (GND), J1.116 (GND), J1.117 (GND), J1.118 (GND), J1.119 (GND), J1.120 (GND), J1.121, J1.122, J2.18, J3.10, J3.15, J3.16, J3.23, J3.24, JP1.2, JP2.1, SW1.8, SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW2.7, SW2.8, SW2.9, SW2.10, SW2.11, SW2.12, U1.10 (GND), U2.10 (GND), U3.10 (GND), U4.10 (GND), U5.1 (1OE), U5.10 (GND), U5.19 (2OE), U6.1 (1OE), U6.10 (GND)
unnamed: D1.1 (K), U5.9 (2Y3)
unnamed: D1.2 (A), R2.2
unnamed: D2.1 (K), U6.18 (1Y0)
unnamed: D2.2 (A), R3.2
unnamed: D3.1 (K), U6.16 (1Y1)
unnamed: D3.2 (A), R4.2
unnamed: D4.1 (K), U6.14 (1Y2)
unnamed: D4.2 (A), R5.2
unnamed: D5.1 (K), U6.12 (1Y3)
unnamed: D5.2 (A), R6.2
unnamed: J4.1, J4.3, J4.5, J4.7, J4.9, J4.11, J4.13, J4.15, U4.12 (IO8)
unnamed: JP2.2, U3.3 (I3)
unnamed: SW1.1, U1.1 (I1/CLK)
unnamed: SW1.2, U1.2 (I2)
unnamed: SW1.3, U1.3 (I3)
unnamed: SW1.4, U1.4 (I4)
unnamed: SW1.5, U1.5 (I5)
unnamed: SW1.6, U1.6 (I6)
unnamed: SW1.7, U1.7 (I7)
unnamed: SW2.1, U2.1 (I1/CLK)
unnamed: SW2.2, U2.2 (I2)
unnamed: SW2.3, U2.3 (I3)
unnamed: SW2.4, U2.4 (I4)
unnamed: SW2.5, U2.5 (I5)
unnamed: SW2.6, U2.6 (I6)
unnamed: U1.16 (IO4), U3.1 (I1/CLK)

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
Board: 2 copper layers, 100.0 x 100.0 mm, 35 parts (0 on the bottom side), 107 nets.
